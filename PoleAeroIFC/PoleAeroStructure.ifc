Properties of the parts of a building model (IFC2X3), part 4 of 5

# IfcColumn: PL10*60 (40)
Name | Longueur (mm) | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
4 x MONTANT | 857.6 | +8.250 | +9.108 | 281 | MC2 | 1 | 5 | 857.6 | 0.118529 | 0.00050256

# IfcColumn: PL100*5 (6)
In: Undefined
Description: PL100*5; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.450; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL100*5; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 100 mm; Largeur: 5 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x FEUILLURE | +10.295 | 142 | M15 | 0.4 | 1845 | 0.38845 | 0.0009225
2 x FEUILLURE | +11.120 | 141 | M14 | 0.7 | 2670 | 0.5617 | 0.001335
2 x FEUILLURE | +11.920 | 140 | M13 | 0.7 | 3470 | 0.7297 | 0.001735

# IfcColumn: PL2*100 (7)
In: Undefined
Description: PL2*100; Material: MISCELLANEOUS/PVC
Tekla Commun - Niveau bas: +8.340; Niveau haut: +8.440; Repère de pièce: O1; Repère d'assemblage: O1; Phase: 3; Classe: 5; Matériau: PVC; Profil: PL2*100; Nom: OBTURATEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 737.6 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 2 mm; Longueur: 100 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: O1
BaseQuantities - Length: 100.004 mm; OuterSurfaceArea: 0.0208008 m2; NetVolume: 0.0000200007 m3; NetWeight: 0.028201 kg

# IfcColumn: PL5*60 (18)
In: Undefined
Description: PL5*60; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.300; Niveau haut: +9.108; Repère de pièce: 304; Phase: 1; Classe: 5; Matériau: S235-E24; Profil: PL5*60; Nom: MONTANT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 60 mm; Largeur: 5 mm; Longueur: 807.6 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: 304
BaseQuantities - Length: 807.6 mm; OuterSurfaceArea: 0.10302 m2; NetVolume: 0.00023628 m3; NetWeight: 0 kg
Name | Repère d'assemblage
4 x MONTANT | MC3
12 x MONTANT | MC1
2 x MONTANT | MC2

# IfcColumn: PL6*100 (5)
In: Undefined
Description: PL6*100; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL6*100; Nom: CALE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 6 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
CALE | +8.083 | +8.183 | C2 | 100 | 0.0224 | 0.00006
CALE | +8.202 | +8.302 | C2 | 100 | 0.0224 | 0.00006
3 x CALE | +8.350 | +8.445 | C1 | 95 | 0.02134 | 0.000057

# IfcColumn: PL8*100, CALE
In: Undefined
Description: PL8*100; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.350; Niveau haut: +8.445; Repère de pièce: C3; Repère d'assemblage: C3; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL8*100; Nom: CALE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 8 mm; Longueur: 95 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: C3
BaseQuantities - Length: 95 mm; OuterSurfaceArea: 0.02212 m2; NetVolume: 0.000076 m3; NetWeight: 0 kg

# IfcColumn: TUBE-C-100*100*4 (14)
In: Undefined
Description: TUBE-C-100*100*4; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Matériau: S235-E24; Profil: TUBE-C-100*100*4; Nom: MONTANT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 100 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Classe | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
3 x MONTANT | +5.005 | +7.095 | M10 | M10 | 2 | 0.7 | 2090 | 0.80674 | 0.00321024
2 x MONTANT | +8.555 | +10.190 | 88 | M15 | 2 | 0.7 | 1635 | 0.63111 | 0.00251136
2 x MONTANT | +8.555 | +11.015 | 87 | M14 | 2 | 1 | 2460 | 0.94956 | 0.00377856
2 x MONTANT | +8.555 | +11.815 | 86 | M13 | 2 | 1.2 | 3260 | 1.25836 | 0.00500736
2 x MONTANT | +2.865 | +4.935 | M12 | M12 | 3 | 0.7 | 2070 | 0.79902 | 0.00317952
MONTANT | +1.105 | +4.935 | M17 | M17 | 3 | 1.5 | 3830 | 1.47838 | 0.00588288
2 x MONTANT | +1.105 | +2.795 | M11 | M11 | 2 | 0.7 | 1690 | 0.65234 | 0.00259584

# IfcColumn: TUBE-C-100*100*5 (14)
In: Undefined
Description: TUBE-C-100*100*5; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.062; Finition: GALVA; Phase: 3; Classe: 8; Matériau: S235-E24; Profil: TUBE-C-100*100*5; Nom: POTELET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 100 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
6 x POTELET | +8.432 | 565 | P4 | 0.7 | 1370 | 0.52471 | 0.002603
8 x POTELET | +7.842 | 564 | P3 | 0.4 | 780 | 0.29874 | 0.001482

# IfcColumn: TUBE-C-80*80*4 (4)
In: Undefined
Description: TUBE-C-80*80*4; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.110; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TUBE-C-80*80*4; Nom: MONTANT BARDAGE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 80 mm; Largeur: 80 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MONTANT BARDAGE | +10.180 | M21 | 1.6 | 5070 | 1.55142 | 0.00616512
2 x MONTANT BARDAGE | +8.550 | M1 | 1.1 | 3440 | 1.05264 | 0.00418304
MONTANT BARDAGE | +10.680 | M2 | 1.7 | 5570 | 1.70442 | 0.00677312

# IfcColumn: TUBE-R-100*50*3 (9)
In: Undefined
Description: TUBE-R-100*50*3; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.250; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TUBE-R-100*50*3; Nom: SUSPENTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 100 mm; Largeur: 50 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
3 x SUSPENTE | +9.723 | 209 | S22 | 0.4 | 1472.8 | 1472.77 | 0.425632 | 0.0012618
3 x SUSPENTE | +10.501 | 208 | S21 | 0.7 | 2250.8 | 2250.8 | 0.650481 | 0.0019335
3 x SUSPENTE | +11.250 | 207 | S20 | 1 | 3000.2 | 3000.17 | 0.86705 | 0.00258085

# IfcColumn: UPF-100*50*4 (4)
In: Undefined
Description: UPF-100*50*4; Material: Undefined/S235-E24
Tekla Commun - Niveau haut: +8.445; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: UPF-100*50*4; Nom: BAIONNETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 100 mm; Largeur: 50 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
BAIONNETTE | +7.690 | B6 | 0.4 | 755 | 754.999 | 0.275055 | 0.000534959
BAIONNETTE | +7.775 | B12 | 0.2 | 670 | 669.999 | 0.241735 | 0.000469679
BAIONNETTE | +7.655 | B10 | 0.4 | 790 | 789.999 | 0.288775 | 0.000561839
BAIONNETTE | +7.535 | B8 | 0.4 | 910 | 909.999 | 0.335815 | 0.000653999

# IfcElementAssembly (1532)
In: Undefined
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
2 x COIFFE | 0 | +8.490 | +8.593 | 4-5/E | C0(?) | 134.078
COIFFE | 0 | +8.490 | +8.593 | 4-7/E | C0(?) | 134.078
COIFFE | 0 | +8.490 | +8.593 | 7-8/E | C0(?) | 134.078
COIFFE | 0 | +8.490 | +8.593 | 6-7/E | C0(?) | 134.078
COIFFE | 0 | +8.490 | +8.600 | 6-7/E | C4(?) | 456.94
CACHE VIDE | 0 | +8.110 | +8.116 | 6-8/E-A | GC0(?) | 6
CACHE VIDE | 0 | +7.531 | +8.111 | 7-8/E-A | GC0(?) | 6
CACHE VIDE | 0 | +8.110 | +8.116 | 4-5/E-A | GC0(?) | 6
CACHE VIDE | 0 | +7.531 | +8.111 | 5-6/E-A | GC0(?) | 6
MAIN COURANTE | 0 | +8.700 | +8.706 | 2-4/E-A | GC0(?) | 6
COIFFE | 0 | +8.659 | +8.740 | 2-3/E | C5(?) | 101.774
MAIN COURANTE | 0 |  |  |  | GC0(?) | 977.6
MONTANT | 0 | +8.710 | +9.678 | 4-5/E-A | 0(?) | 10
2 x MAIN COURANTE | 0 |  |  |  | GC0(?) | 901.923
3 x CONSOLE | 0 | +8.175 | +8.475 | 2-3/E-A | C9 | 300
4 x CONSOLE | 0 | +8.175 | +8.475 | 3-4/E-A | C9 | 300
PLATINE | 0 | +8.700 | +8.710 | 3-4/E-A | 0(?) | 10
MONTANT | 0 | +8.710 | +9.678 | 3-4/E-A | 0(?) | 10
PLINTHE | 0 | +8.710 | +8.810 | 3-5/E-A | 0(?) | 5
MAIN COURANTE | 0 |  |  |  | GC12 | 2117.35
MAIN COURANTE | 0 |  |  |  | GC8 | 2117.35
MAIN COURANTE | 0 |  |  |  | GC10 | 977.6
MAIN COURANTE | 0 |  |  |  | GC4 | 977.6
2 x MAIN COURANTE | 0 |  |  |  | GC2 | 1211.44
MAIN COURANTE | 0 |  |  |  | GC6 | 977.6
MAIN COURANTE | 0 |  |  |  | GC3 | 1211.45
MAIN COURANTE | 0 |  |  |  | GC1 | 1211.44
2 x MAIN COURANTE | 0 |  |  |  | GC3 | 1211.44
MAIN COURANTE | 0 |  |  |  | GC7 | 977.6
4 x POTELET | 0 | +7.050 | +8.440 | 4-5/E-A | P4 | 300
4 x ATTACHE | 0 | +8.440 | +8.500 | 4-5/E-A | A29 | 60
PALIER | 0 | +8.670 | +8.700 | 2-3/E-A | P6(?) | 30
PALIER | 0 | +8.670 | +8.700 | 2-3/E-A | P10(?) | 30
5 x PALIER | 0 | +8.670 | +8.700 | 3-4/E-A | P10(?) | 30
2 x PALIER | 0 | +8.670 | +8.700 | 4-5/E-A | P10(?) | 30
SUPPORT | 0 | +8.620 | +8.670 | 2-4/E-A | S51 | 50
SUPPORT | 0 | +8.620 | +8.670 | 3-5/E-A | S33 | 50
2 x ATTACHE | 0 | +8.480 | +8.660 | 2-3/E-A | A45 | 60
MARCHE | 0 | +8.630 | +8.700 | C3-C4/CB | M18 | 70
MARCHE | 0 | +8.450 | +8.520 | C3-C4/CA-CB | M18 | 70
MARCHE | 0 | +8.270 | +8.340 | C3-C4/CA-CB | M18 | 70
MARCHE | 0 | +8.090 | +8.160 | C3-C4/CA-CB | M18 | 70
LIMON | 0 | +8.049 | +8.910 | 2-3/E-A | L90 | 90.0092
SUPPORT | 0 | +8.800 | +8.850 | 2-3/E | S54 | 50
2 x ATTACHE | 0 | +8.700 | +8.840 | 2-3/E-A | A80 | 140
SUPPORT | 0 | +8.800 | +8.850 | 2-3/E | S53 | 50
LIMON | 0 | +8.049 | +8.910 | 2-3/E-A | L89 | 90.0011
2 x DALLE SUR PLOT | 30 | +7.995 | +8.061 | C3-C4/CA-CB | DP1 | 50 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assemblages - Poids ferraillage Elément béton: 0 kg
Steel Assembly | 1.9 | +7.944 | +8.012 | C3-C4/CA-CB | S55 | 50
PALIER | 0 | +8.850 | +8.880 | 2-3/E-A | P5(?) | 30
MARCHE | 0 | +8.630 | +8.700 | C5-C6/CB | M18 | 70
MARCHE | 0 | +8.450 | +8.520 | C5-C6/CA-CB | M18 | 70
MARCHE | 0 | +8.270 | +8.340 | C5-C6/CA-CB | M18 | 70
MARCHE | 0 | +8.090 | +8.160 | C5-C6/CA-CB | M18 | 70
LIMON | 0 | +8.049 | +8.910 | 4-5/E-A | L90 | 90.0092
SUPPORT | 0 | +8.800 | +8.850 | 4-5/E | S54 | 50
2 x ATTACHE | 0 | +8.700 | +8.840 | 4-5/E-A | A80 | 140
SUPPORT | 0 | +8.800 | +8.850 | 4-5/E | S53 | 50
LIMON | 0 | +8.049 | +8.910 | 4-5/E-A | L89 | 90.0011
2 x DALLE SUR PLOT | 30 | +7.995 | +8.061 | C5-C6/CA-CB | DP1 | 50 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assemblages - Poids ferraillage Elément béton: 0 kg
Steel Assembly | 1.9 | +7.944 | +8.012 | C5-C6/CA-CB | S55 | 50
PALIER | 0 | +8.850 | +8.880 | 4-5/E-A | P5(?) | 30
SUPPORT | 0 | +8.620 | +8.670 | 2-4/E-A | S25 | 50
SUPPORT | 0 | +8.620 | +8.670 | 3-5/E-A | S41 | 50
2 x DALLE SUR PLOT | 30 | +7.995 | +8.061 | C7-C8/CA-CB | DP1 | 50 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assemblages - Poids ferraillage Elément béton: 0 kg
Steel Assembly | 1.9 | +7.944 | +8.012 | C7-C8/CA-CB | S55 | 50
LIMON | 0 | +8.049 | +8.910 | 6-7/E-A | L90 | 90.0092
SUPPORT | 0 | +8.800 | +8.850 | 6-7/E | S54 | 50
SUPPORT | 0 | +8.800 | +8.850 | 6-7/E | S53 | 50
2 x ATTACHE | 0 | +8.440 | +8.500 | 6-7/E-A | A29 | 60
2 x ATTACHE | 0 | +7.850 | +7.910 | 6-7/E-A | A29 | 60
2 x ATTACHE | 0 | +7.850 | +7.910 | 7/E-A | A29 | 60
MARCHE | 0 | +8.630 | +8.700 | C7-C8/CB | M18 | 70
MARCHE | 0 | +8.450 | +8.520 | C7-C8/CA-CB | M18 | 70
MARCHE | 0 | +8.270 | +8.340 | C7-C8/CA-CB | M18 | 70
MARCHE | 0 | +8.090 | +8.160 | C7-C8/CA-CB | M18 | 70
MARCHE | 0 | +8.433 | +8.503 | 6-7/E-A | M37 | 70
MARCHE | 0 | +8.237 | +8.307 | 6-7/E-A | M37 | 70
MARCHE | 0 | +7.840 | +7.910 | 7-8/E-A | M37 | 70
MARCHE | 0 | +7.640 | +7.710 | 7-8/E-A | M37 | 70
MARCHE | 0 | +7.440 | +7.510 | 7-8/E-A | M37 | 70
2 x POTELET | 0 | +7.050 | +8.440 | 6-7/E-A | P4 | 300
2 x POTELET | 0 | +7.050 | +7.850 | 6-7/E-A | P3 | 300
2 x POTELET | 0 | +7.050 | +7.850 | 7/E-A | P3 | 300
2 x SUPPORT | 0 | +8.030 | +8.080 | 6-7/E-A | S35 | 50
2 x SUPPORT | 0 | +8.620 | +8.670 | 6-7/E-A | S52 | 50
2 x ATTACHE | 0 | +8.700 | +8.840 | 6-7/E-A | A80 | 140
LIMON | 0 | +8.049 | +8.910 | 6-7/E-A | L89 | 90.0011
2 x ATTACHE | 0 | +8.480 | +8.660 | 6-7/E-A | A45 | 60
SUPPORT | 0 | +8.620 | +8.670 | 6-7/E-A | S36 | 50
LIMON | 0 | +7.370 | +8.700 | 6-8/E-A | L33(?) | 90.0065
LIMON | 0 | +7.370 | +8.700 | 6-8/E-A | L63 | 90.0018
COIFFE | 0 | +8.069 | +8.150 | 6-7/E | C5 | 101.774
PALIER | 0 | +8.080 | +8.110 | 6-8/E-A | P10(?) | 30
PALIER | 0 | +8.670 | +8.700 | 6-7/E-A | P11(?) | 30
PALIER | 0 | +8.080 | +8.110 | 6-7/E-A | P10(?) | 30
PALIER | 0 | +8.850 | +8.880 | 6-7/E-A | P5(?) | 30
LIMON | 0 | +8.440 | +8.700 | 6-7/E-A | L91 | 90
4 x Steel Assembly | 0 | +8.340 | +8.440 | 3-4/E-A | O1 | 2
2 x LIMON | 0 | +8.440 | +8.700 | 3-4/E-A | L92(?) | 90
COIFFE | 0 | +8.485 | +8.600 | 4/E-A | C8(?) | 561.113
3 x PANNE SHED | 0 | +8.626 | +8.933 | C7/CA-CB | PN19 | 150
2 x PANNE SHED | 0 | +8.771 | +8.919 | C7/CA-CB | PN21 | 140
3 x PANNE SHED | 0 | +8.619 | +8.929 | C8'/CA-CB | PN19 | 150
2 x PANNE SHED | 0 | +8.768 | +8.916 | C8'/CA-CB | PN20 | 140
PANNE SHED | 0 | +12.474 | +12.679 | C4/CA-CB | PN26 | 210
2 x PANNE SHED | 0 | +12.474 | +12.679 | C4/CA-CB | PN33 | 210
PANNE SHED | 0 | +12.474 | +12.679 | C4/CA-CB | PN28 | 210
PANNE SHED | 0 | +11.671 | +11.876 | C6/CA-CB | PN26 | 210
2 x PANNE SHED | 0 | +11.671 | +11.876 | C6/CA-CB | PN33 | 210
PANNE SHED | 0 | +11.671 | +11.876 | C6/CA-CB | PN28 | 210
PANNE SHED | 0 | +10.851 | +11.053 | C8/CA-CB | PN29 | 210
2 x PANNE SHED | 0 | +10.851 | +11.053 | C8/CA-CB | PN34 | 210
PANNE SHED | 0 | +10.851 | +11.053 | C8/CA-CB | PN27 | 210
PANNE SHED | 0 | +8.768 | +8.916 | C8'/CA-CB | PN31 | 140
PANNE SHED | 0 | +8.768 | +8.916 | C8'/CA-CB | PN22 | 140
PANNE SHED | 0 | +8.771 | +8.919 | C7/CA-CB | PN32 | 140
PANNE SHED | 0 | +8.771 | +8.919 | C7/CA-CB | PN23 | 140
PANNE SHED | 0 | +8.772 | +8.919 | C5/CA-CB | PN32 | 140
2 x PANNE SHED | 0 | +8.772 | +8.919 | C5/CA-CB | PN21 | 140
PANNE SHED | 0 | +8.772 | +8.919 | C5/CA-CB | PN23 | 140
SUPPORT | 0 | +5.155 | +5.230 | <5'/<E | S48 | 75
SUPPORT | 0 | +5.080 | +5.230 | <5'/<E | S50 | 4
SUPPORT | 0 | +5.155 | +5.230 | <5'-6''/<E | S47 | 75
SUPPORT | 0 | +5.080 | +5.230 | <5'/<E | S49 | 4
SUPPORT | 0 | +5.080 | +5.230 | <5'-6'/<E | S46 | 4
SUPPORT | 0 | +5.080 | +5.230 | 5'-6''/<E | S46 | 4
3 x SUPPORT | 0 | +5.080 | +5.230 | <5'/<E | S45 | 4
CONTRE PLATINE | 0 | +5.215 | +5.480 | C7/CA | CP1 | 10
CONTRE PLATINE | 0 | +5.215 | +5.480 | C4/CA | CP1 | 10
2 x ATTACHE | 0 | +5.370 | +5.450 | C7/CA | A78 | 80
2 x ATTACHE | 0 | +5.370 | +5.450 | C6-C7/CA | A78 | 80
2 x ATTACHE | 0 | +5.370 | +5.450 | C6/CA | A78 | 80
2 x ATTACHE | 0 | +5.370 | +5.450 | C5-C6/CA | A78 | 80
2 x ATTACHE | 0 | +5.370 | +5.450 | C5/CA | A78 | 80
2 x ATTACHE | 0 | +5.370 | +5.450 | C4-C5/CA | A78 | 80
2 x ATTACHE | 0 | +5.370 | +5.450 | C4/CA | A78 | 80
SUPPORT | 0 | +5.450 | +5.500 | C5-C8/CA | S44 | 50
SUPPORT | 0 | +5.450 | +5.500 | C3-C6/CA | S43 | 50
2 x ATTACHE | 0 | +5.230 | +5.310 | 6'/<E | A79 | 80
2 x ATTACHE | 0 | +5.230 | +5.310 | 5'-6'/<E | A79 | 80
10 x ATTACHE | 0 | +5.230 | +5.310 | <5'/<E | A79 | 80
4 x CONSOLE | 0 | +5.215 | +5.480 | <5'/<E | C11 | 200
CONSOLE | 0 | +5.215 | +5.480 | 5'-6'/<E | C11 | 200
CONSOLE | 0 | +5.215 | +5.480 | 6'/<E | C12 | 200
CONSOLE | 0 | +5.215 | +5.480 | <5'/<E | C12 | 200
ATTACHE | 0 | +5.340 | +5.440 | C6/CA | A77 | 75
ATTACHE | 0 | +5.340 | +5.440 | C6-C7/CA | A77 | 75
ATTACHE | 0 | +5.340 | +5.440 | C5/CA | A77 | 75
ATTACHE | 0 | +5.340 | +5.440 | C4-C5/CA | A77 | 75
SUPPORT | 0 | +5.000 | +5.080 | C5-C7/CA | S42 | 10
SUPPORT | 0 | +5.000 | +5.080 | C4-C6/CA | S16 | 10
POTEAU | 0 | -0.200 | +8.445 | C9/CA | PT4 | 310
POTEAU | 0 | -0.200 | +8.445 | C3/CA | PT5 | 310
ATTACHE | 0 | +2.660 | +2.800 | C3/CA | A75 | 200
ATTACHE | 0 | +4.830 | +4.940 | C4/CA | A76 | 70
ATTACHE | 0 | +4.800 | +4.940 | C3/CA | A75 | 200
ATTACHE | 0 | +4.800 | +4.940 | C9/CA | A75 | 200
ATTACHE | 0 | +4.800 | +4.940 | C8/CA | A75 | 200
MONTANT | 0 | +1.105 | +4.935 | C8-C8'/CA | M17 | 100
ATTACHE | 0 | +1.100 | +1.170 | C8-C8'/CA | A32 | 70
ATTACHE | 0 | +2.690 | +2.760 | C8-C8'/CA | A32 | 70
LISSE CHASSIS | 0 | +2.760 | +2.860 | C8-C9/CA | L29 | 170
ATTACHE | 0 | +2.860 | +2.930 | C8'/CA | A32 | 70
ATTACHE | 0 | +2.660 | +2.760 | C9/CA | A44 | 100
POTEAU | 0 | -0.200 | +2.682 | 6''/A' | PT13 | 180
POTEAU | 0 | -0.200 | +2.682 | 6'/A' | PT11 | 180
TRAVERSE | 0 | +2.674 | +3.045 | 6''/E-A' | T6 | 82
TRAVERSE | 0 | +2.674 | +3.045 | 6'/E-A' | T9 | 82
BAVETTE | 0 | +4.450 | +4.555 | 4-8/A | X1 | 43.7883
BAVETTE | 0 | +2.800 | +2.905 | 4-8/A | X1 | 43.7883
COIFFE | 0 | +8.069 | +8.150 | 4-5/E | C5 | 101.774
GOUSSET | 0 | +2.481 | +2.650 | 6'/A' | G32 | 5
2 x STABILTE | 0 | -0.108 | +2.580 | 6'-6''/A' | S14 | 40
GOUSSET | 0 | -0.175 | -0.006 | 6''/A' | G32 | 5
GOUSSET | 0 | -0.175 | -0.006 | 6'/A' | G32 | 5
GOUSSET | 0 | +2.481 | +2.650 | 6''/A' | G32 | 5
ATTACHE | 0 | +0.036 | +0.146 | 6'/A' | A16 | 147
ATTACHE | 0 | +1.376 | +1.486 | 6'/A' | A16 | 147
ATTACHE | 0 | +0.036 | +0.146 | 6''/A' | A16 | 147
ATTACHE | 0 | +1.376 | +1.486 | 6''/A' | A16 | 147
2 x FEUILLURE | 0 | +2.784 | +2.840 | 6'-6''/A' | F18 | 50.0885
GOUSSET | 0 | +3.025 | +3.042 | 6'/E-A' | G30 | 5
GOUSSET | 0 | +3.025 | +3.042 | 6''/E-A' | G30 | 5
GOUSSET | 0 | +2.834 | +2.851 | 6''/A' | G30 | 5
GOUSSET | 0 | +2.834 | +2.851 | 6'/A' | G30 | 5
GOUSSET | 0 | +2.924 | +2.947 | 6'-6''/E-A' | G31 | 5
2 x STABILITE CVT | 0 | +2.945 | +3.074 | 6'-6''/E-A' | S15 | 40
PANNE | 0 | +3.036 | +3.159 | 5'-7'/E-A' | PN37 | 64
PANNE | 0 | +2.936 | +3.059 | 5'-7'/E-A' | PN36 | 64
PANNE | 0 | +2.836 | +2.960 | 5'-7'/A' | PN11 | 64
GOUSSET | 0 | +2.800 | +3.050 | 6'/E | G29 | 160
GOUSSET | 0 | +2.800 | +3.050 | 6''/E | G29 | 160
GOUSSET | 0 | +2.896 | +3.213 | 5'/E-A' | G11 | 82
GOUSSET | 0 | +4.121 | +4.430 | 5'/E | G28 | 160
GOUSSET | 0 | +2.800 | +3.050 | 5'/E | G29 | 160
BUTON | 0 | +3.103 | +4.231 | 5'/E-A' | B14 | 80
GOUSSET | 0 | +2.800 | +3.050 | 7'/E | G29 | 160
GOUSSET | 0 | +4.121 | +4.430 | 7'/E | G28 | 160
GOUSSET | 0 | +2.896 | +3.213 | 7'/E-A' | G11 | 82
BUTON | 0 | +3.103 | +4.231 | 7'/E-A' | B14 | 80
2 x ATTACHE | 0 | +7.850 | +7.910 | 4-5/E-A | A29 | 60
2 x ATTACHE | 0 | +7.850 | +7.910 | 5/E-A | A29 | 60
MARCHE | 0 | +8.433 | +8.503 | 4-5/E-A | M37 | 70
MARCHE | 0 | +8.237 | +8.307 | 4-5/E-A | M37 | 70
MARCHE | 0 | +7.840 | +7.910 | 5/E-A | M37 | 70
MARCHE | 0 | +7.640 | +7.710 | 5/E-A | M37 | 70
MARCHE | 0 | +7.440 | +7.510 | 5-6/E-A | M37 | 70
2 x POTELET | 0 | +7.050 | +7.850 | 4-5/E-A | P3 | 300
2 x POTELET | 0 | +7.050 | +7.850 | 5/E-A | P3 | 300
2 x SUPPORT | 0 | +8.030 | +8.080 | 4-5/E-A | S35 | 50
LIMON | 0 | +7.370 | +8.700 | 4-5/E-A | L5(?) | 90.0039
LIMON | 0 | +7.370 | +8.700 | 4-5/E-A | L75(?) | 90.0074
COIFFE | 0 | +8.490 | +8.600 | 4-5/E | C4(?) | 456.94
2 x PALIER | 0 | +8.080 | +8.110 | 4-5/E-A | P10(?) | 30
PALIER | 0 | +8.670 | +8.700 | 4-5/E-A | P11(?) | 30
SUPPORT | 0 | +8.620 | +8.670 | 2-3/E-A | S36 | 50
3 x Steel Assembly | 0 | +8.340 | +8.440 | 2-3/E-A | O1 | 2
PALIER | 0 | +8.670 | +8.700 | 2-3/E-A | P8(?) | 30
COIFFE | 0 | +8.485 | +8.600 | 2-3/E | C6 | 541.223
LIMON | 0 | +8.440 | +8.700 | 2-3/E-A | L88 | 90
LIMON | 0 | +8.440 | +8.700 | 2-3/E-A | L87(?) | 90
COIFFE | 0 | +8.485 | +8.600 | 3/E-A | C7(?) | 630.73
LIMON | 0 | +8.440 | +8.700 | 2-3/E-A | L93 | 90
CAILLEBOTIS | 0 | +8.100 | +8.130 | C8-C8'/CA-CB | CA4 | 30
3 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C8-C8'/CA-CB | CA3 | 30
4 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C8-C8'/CA-CB | CA2 | 30
8 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C8-C8'/CA-CB | CA1 | 30
4 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C6-C7/CA-CB | CA3 | 30
4 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C6-C7/CA-CB | CA2 | 30
8 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C6-C7/CA-CB | CA1 | 30
4 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C4-C5/CA-CB | CA3 | 30
4 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C4-C5/CA-CB | CA2 | 30
8 x CAILLEBOTIS | 0 | +8.100 | +8.130 | C4-C5/CA-CB | CA1 | 30
SUPPORT | 0 | +5.010 | +5.080 | C4-C6/CA | S32 | 70
SUPPORT | 0 | +5.010 | +5.080 | C5-C7/CA | S10 | 70
GOUSSET | 0 | +8.546 | +8.649 | C5/CB | G12 | 6
ATTACHE | 0 | +8.493 | +8.630 | C5/CB | A28 | 60
LISSE CHASSIS | 0 | +1.000 | +1.100 | C8-C9/CA | L25 | 170
LISSE CHASSIS | 0 | +4.900 | +5.000 | C2-C3/CA | L55 | 170
LISSE CHASSIS | 0 | +1.000 | +1.100 | C2-C3/CA | L2 | 170
ATTACHE | 0 | +8.410 | +8.470 | C6/CA | A13 | 170
LISSE ACROTERE | 0 | +8.470 | +8.550 | C5-C6/CA | L1 | 80
ATTACHE | 0 | +8.410 | +8.470 | C5/CA | A13 | 170
MONTANT BARDAGE | 0 | +5.110 | +10.180 | C6-C7/CA | M21 | 80
ATTACHE | 0 | +8.110 | +8.210 | C6-C7/CA | A18 | 80
MONTANT BARDAGE | 0 | +5.110 | +8.550 | C6/CA | M1 | 80
ATTACHE | 0 | +8.110 | +8.210 | C6/CA | A18 | 80
MONTANT BARDAGE | 0 | +5.110 | +8.550 | C5/CA | M1 | 80
ATTACHE | 0 | +8.110 | +8.210 | C5/CA | A18 | 80
MONTANT BARDAGE | 0 | +5.110 | +10.680 | C4-C5/CA | M2 | 80
ATTACHE | 0 | +8.110 | +8.210 | C4-C5/CA | A18 | 80
ATTACHE | 0 | +10.103 | +10.265 | C4-C5/CA | A12 | 64.3434
ATTACHE | 0 | +9.596 | +9.759 | C6-C7/CA | A12 | 117.724
SUPPORT CHARGE BARDAG | 0 | +5.000 | +5.080 | C5-C6/CA | S26 | 260
SUPPORT CHARGE BARDAG | 0 | +5.000 | +5.080 | C6-C7/CA | S23 | 260
SUPPORT CHARGE BARDAG | 0 | +5.000 | +5.080 | C5-C7/CA | S23 | 260
SUPPORT CHARGE BARDAG | 0 | +5.000 | +5.080 | C4-C6/CA | S24 | 260
2 x SUPPORT CHARGE BARDAG | 0 | +5.000 | +5.080 | C4-C5/CA | S23 | 260
PANNE SHED | 0 | +8.627 | +8.933 | C5/CB | PN19 | 150
PANNE SHED | 0 | +9.358 | +9.664 | C4-C5/CB | PN19 | 150
PANNE SHED | 0 | +10.110 | +10.416 | C4-C5/CB | PN19 | 150
PANNE SHED | 0 | +10.862 | +11.168 | C4-C5/CB | PN19 | 150
PANNE SHED | 0 | +8.626 | +8.933 | C7/CB | PN19 | 150
PANNE SHED | 0 | +9.344 | +9.651 | C6-C7/CB | PN19 | 150
PANNE SHED | 0 | +10.084 | +10.390 | C6-C7/CB | PN19 | 150
PANNE SHED | 0 | +8.619 | +8.929 | C8'/CB | PN19 | 150
PANNE SHED | 0 | +9.312 | +9.621 | C8-C8'/CB | PN19 | 150
PANNE SHED | 0 | +10.823 | +11.130 | C6-C7/CB | PN19 | 150
PANNE SHED | 0 | +10.024 | +10.334 | 7/E | PN19 | 150
PANNE SHED | 0 | +11.614 | +11.920 | C4-C5/CB | PN19 | 150
3 x PANNE SHED | 0 | +8.627 | +8.933 | C5/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +9.358 | +9.664 | C4-C5/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +10.110 | +10.416 | C4-C5/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +10.862 | +11.168 | C4-C5/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +9.344 | +9.651 | C6-C7/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +10.084 | +10.390 | C6-C7/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +9.312 | +9.621 | C8-C8'/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +10.823 | +11.130 | C6-C7/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +10.024 | +10.334 | C8-C8'/CA-CB | PN19 | 150
3 x PANNE SHED | 0 | +11.614 | +11.920 | C4-C5/CA-CB | PN19 | 150
PANNE SHED | 0 | +8.627 | +8.933 | C5/CA | PN19 | 150
PANNE SHED | 0 | +9.358 | +9.664 | C4-C5/CA | PN19 | 150
PANNE SHED | 0 | +10.110 | +10.416 | C4-C5/CA | PN19 | 150
PANNE SHED | 0 | +10.862 | +11.168 | C4-C5/CA | PN19 | 150
PANNE SHED | 0 | +8.626 | +8.933 | C7/CA | PN19 | 150
PANNE SHED | 0 | +9.344 | +9.651 | C6-C7/CA | PN19 | 150
PANNE SHED | 0 | +10.084 | +10.390 | C6-C7/CA | PN19 | 150
PANNE SHED | 0 | +8.619 | +8.929 | C8'/CA | PN19 | 150
PANNE SHED | 0 | +9.312 | +9.621 | C8-C8'/CA | PN19 | 150
PANNE SHED | 0 | +10.823 | +11.130 | C6-C7/CA | PN19 | 150
PANNE SHED | 0 | +10.024 | +10.334 | C8-C8'/CA | PN19 | 150
PANNE SHED | 0 | +11.614 | +11.920 | C4-C5/CA | PN19 | 150
FEUILLURE | 0 | +6.250 | +8.430 | C7/CA | F12 | 130
FEUILLURE | 0 | +3.250 | +6.250 | C7/CA | F11 | 130
FEUILLURE | 0 | +0.250 | +3.250 | C7/CA | F9 | 130
FEUILLURE | 0 | +6.250 | +8.430 | C4/CA | F7 | 130
FEUILLURE | 0 | +3.250 | +6.250 | C4/CA | F10 | 130
FEUILLURE | 0 | +0.250 | +3.250 | C4/CA | F6 | 130
FEUILLURE | 0 | +8.080 | +8.430 | C1/CB | F8 | 80
FEUILLURE | 0 | +7.390 | +8.010 | C1/CB | F5 | 80
FEUILLURE | 0 | +6.250 | +7.370 | C1/CB | F2 | 80
FEUILLURE | 0 | +3.250 | +6.250 | C1/CB | F17 | 80
FEUILLURE | 0 | +0.250 | +3.250 | C1/CB | F1 | 80
FEUILLURE | 0 | +7.860 | +8.420 | C1/CA | F4 | 80
FEUILLURE | 0 | +6.250 | +7.840 | C1/CA | F3 | 80
FEUILLURE | 0 | +3.250 | +6.250 | C1/CA | F1 | 80
FEUILLURE | 0 | +0.250 | +3.250 | C1/CA | F1 | 80
BUTON | 0 | +7.462 | +7.722 | C4-C5/CA-CB | B5 | 129.254
MONTANT | 0 | +8.048 | +8.550 | C8-C8'/CA | M36 | 146.311
2 x DIAGONALE | 0 | +5.261 | +8.289 | C6-C7/CA | D4 | 45
PLAQUETTE | 0 | +7.658 | +7.718 | C6-C7/CA | P1 | 8
PLAQUETTE | 0 | +7.202 | +7.262 | C6-C7/CA | P1 | 8
2 x PLAQUETTE | 0 | +6.745 | +6.805 | C6-C7/CA | P1 | 8
PLAQUETTE | 0 | +6.288 | +6.348 | C6-C7/CA | P1 | 8
PLAQUETTE | 0 | +5.832 | +5.892 | C6-C7/CA | P1 | 8
2 x DIAGONALE | 0 | +5.255 | +8.295 | C6-C7/CA | D9 | 45
PLAQUETTE | 0 | +7.665 | +7.725 | C6-C7/CA | P1 | 8
PLAQUETTE | 0 | +7.205 | +7.265 | C6-C7/CA | P1 | 8
PLAQUETTE | 0 | +6.285 | +6.345 | C6-C7/CA | P1 | 8
PLAQUETTE | 0 | +5.825 | +5.885 | C6-C7/CA | P1 | 8
2 x DIAGONALE | 0 | +5.271 | +8.279 | C5-C6/CA | D5 | 45
2 x PLAQUETTE | 0 | +7.558 | +7.618 | C5-C6/CA | P1 | 8
2 x PLAQUETTE | 0 | +7.016 | +7.076 | C5-C6/CA | P1 | 8
2 x PLAQUETTE | 0 | +6.474 | +6.534 | C5-C6/CA | P1 | 8
2 x PLAQUETTE | 0 | +5.932 | +5.992 | C5-C6/CA | P1 | 8
2 x DIAGONALE | 0 | +5.271 | +8.279 | C5-C6/CA | D8 | 45
2 x DIAGONALE | 0 | +5.242 | +8.308 | C4-C5/CA | D6 | 45
PLAQUETTE | 0 | +5.744 | +5.804 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +6.144 | +6.204 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +6.545 | +6.605 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +6.945 | +7.005 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +7.346 | +7.406 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +7.746 | +7.806 | C4-C5/CA | P1 | 8
2 x DIAGONALE | 0 | +5.247 | +8.303 | C4-C5/CA | D7 | 45
PLAQUETTE | 0 | +5.816 | +5.876 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +6.281 | +6.341 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +6.745 | +6.805 | C4-C5/CA | P1 | 8
PLAQUETTE | 0 | +7.209 | +7.269 | C4-C5/CA | P1 | 8
8 x DIAGONALE | 0 | +7.296 | +10.377 | C8/CA-CB | D1 | 45
4 x PLAQUETTE | 0 | +9.816 | +9.876 | C8/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +9.412 | +9.472 | C8/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +9.008 | +9.068 | C8/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +8.605 | +8.665 | C8/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +8.201 | +8.261 | C8/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +7.797 | +7.857 | C8/CA-CB | P1 | 8
8 x DIAGONALE | 0 | +7.309 | +11.177 | C6/CA-CB | D2 | 45
4 x PLAQUETTE | 0 | +10.561 | +10.621 | C6/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +10.112 | +10.172 | C6/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +9.662 | +9.722 | C6/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +9.213 | +9.273 | C6/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +8.764 | +8.824 | C6/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +8.314 | +8.374 | C6/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +7.865 | +7.925 | C6/CA-CB | P1 | 8
8 x DIAGONALE | 0 | +7.319 | +11.968 | C4/CA-CB | D3 | 45
4 x PLAQUETTE | 0 | +11.311 | +11.371 | C4/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +10.826 | +10.886 | C4/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +10.341 | +10.401 | C4/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +9.856 | +9.916 | C4/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +9.371 | +9.431 | C4/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +8.886 | +8.946 | C4/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +8.401 | +8.461 | C4/CA-CB | P1 | 8
4 x PLAQUETTE | 0 | +7.916 | +7.976 | C4/CA-CB | P1 | 8
2 x STABILITE | 0 | +7.175 | +7.552 | C8'-C9/CA-CB | S29 | 40
PLAQUETTE | 0 | +7.347 | +7.383 | C9/CA-CB | P2 | 6
2 x STABILITE | 0 | +7.188 | +7.670 | C8'-C9/CA-CB | S28 | 40
PLAQUETTE | 0 | +7.413 | +7.449 | C9/CA-CB | P2 | 6
2 x STABILITE | 0 | +7.202 | +7.790 | C8'-C9/CA-CB | S27 | 40
PLAQUETTE | 0 | +7.480 | +7.516 | C9/CA-CB | P2 | 6
STABILITE CVT | 0 | +7.754 | +7.912 | C8'-C9/CA-CB | S31 | 60
STABILITE CVT | 0 | +7.819 | +7.978 | C8'-C9/CA-CB | S31 | 60
GOUSSET | 0 | +7.906 | +7.918 | C8'/CA-CB | G19 | 6
LIERNE | 0 | +7.700 | +7.863 | C5-C6/CA-CB | L79 | 50
LIERNE | 0 | +7.701 | +7.863 | C5-C6/CA-CB | L79 | 50
LIERNE | 0 | +7.680 | +7.850 | C7-C8/CA-CB | L78 | 50
LIERNE | 0 | +7.681 | +7.850 | C7-C8/CA-CB | L78 | 50
LIERNE | 0 | +7.581 | +7.864 | C5-C6/CA-CB | L81 | 50
LIERNE | 0 | +7.341 | +7.631 | C5-C6/CA-CB | L82 | 50
LIERNE | 0 | +7.321 | +7.611 | C7-C8/CA-CB | L83 | 50
LIERNE | 0 | +7.561 | +7.852 | C7-C8/CA-CB | L80 | 50
GOUSSET | 0 | +7.478 | +7.493 | C4/CA-CB | G22 | 6
GOUSSET | 0 | +7.365 | +7.380 | C4/CB | G22 | 6
GOUSSET | 0 | +7.478 | +7.493 | C3/CA-CB | G22 | 6
GOUSSET | 0 | +7.365 | +7.380 | C3/CB | G22 | 6
GOUSSET | 0 | +7.419 | +7.439 | C3-C4/CA-CB | G25 | 6
GOUSSET | 0 | +7.419 | +7.439 | C2-C3/CA-CB | G24 | 6
GOUSSET | 0 | +7.478 | +7.493 | C3/CA-CB | G21 | 6
GOUSSET | 0 | +7.365 | +7.380 | C3/CB | G21 | 6
GOUSSET | 0 | +7.478 | +7.493 | C2/CA-CB | G21 | 6
GOUSSET | 0 | +7.365 | +7.380 | C2/CB | G21 | 6
STABILITE CVT | 0 | +7.319 | +7.424 | C2-C3/CA-CB | S39 | 50
STABILITE CVT | 0 | +7.319 | +7.424 | C3-C4/CA-CB | S40 | 50
LIERNE | 0 | +7.321 | +7.611 | C3-C4/CA-CB | L84 | 50
LIERNE | 0 | +7.561 | +7.852 | C3-C4/CA-CB | L80 | 50
LIERNE | 0 | +7.321 | +7.611 | C2-C3/CA-CB | L84 | 50
LIERNE | 0 | +7.561 | +7.852 | C2-C3/CA-CB | L80 | 50
GOUSSET | 0 | +7.539 | +7.558 | C1-C2/CA-CB | G23 | 6
GOUSSET | 0 | +7.478 | +7.500 | C2/CA-CB | G26 | 6
STABILITE CVT | 0 | +7.439 | +7.544 | C1-C2/CA-CB | S9 | 50
GOUSSET | 0 | +7.658 | +7.678 | C1-C2/CA-CB | G23 | 6
GOUSSET | 0 | +7.597 | +7.619 | C2/CA-CB | G26 | 6
STABILITE CVT | 0 | +7.558 | +7.663 | C1-C2/CA-CB | S9 | 50
GOUSSET | 0 | +7.777 | +7.797 | C1-C2/CA-CB | G23 | 6
GOUSSET | 0 | +7.716 | +7.739 | C2/CA-CB | G26 | 6
STABILITE CVT | 0 | +7.677 | +7.783 | C1-C2/CA-CB | S9 | 50
GOUSSET | 0 | +7.419 | +7.439 | C1-C2/CA-CB | G23 | 6
GOUSSET | 0 | +7.365 | +7.380 | C2/CB | G20 | 6
STABILITE CVT | 0 | +7.319 | +7.424 | C1-C2/CA-CB | S9 | 50
LIERNE | 0 | +7.321 | +7.611 | C1-C2/CA-CB | L86 | 50
LIERNE | 0 | +7.561 | +7.852 | C1-C2/CA-CB | L85 | 50
GOUSSET | 0 | +7.365 | +7.380 | C1/CB | G20 | 6
GOUSSET | 0 | +7.836 | +7.852 | C1/CA | G20 | 6
GOUSSET | 0 | +7.716 | +7.739 | C1/CA-CB | G26 | 6
GOUSSET | 0 | +7.597 | +7.619 | C1/CA-CB | G26 | 6
GOUSSET | 0 | +7.478 | +7.500 | C1/CA-CB | G26 | 6
GOUSSET | 0 | +7.836 | +7.852 | C2/CA | G20(?) | 6
4 x MAIN COURANTE | 0 |  |  |  | MC3 | 60
2 x MAIN COURANTE | 0 |  |  |  | MC2 | 60
POUTRE | 0 | +7.931 | +8.090 | C8'/CA-CB | A70 | 40
POUTRE | 0 | +7.931 | +8.090 | C7/CA-CB | A70 | 40
POUTRE | 0 | +7.931 | +8.090 | C5/CA-CB | A2 | 40
POUTRE | 0 | +7.811 | +7.970 | C8'/CA-CB | A70 | 40
POUTRE | 0 | +7.811 | +7.970 | C7/CA-CB | A70 | 40
POUTRE | 0 | +7.811 | +7.970 | C5/CA-CB | A69 | 40
POUTRE | 0 | +7.568 | +7.732 | C5/CA-CB | A72 | 40
POUTRE | 0 | +7.568 | +7.732 | C7/CA-CB | A71 | 40
POUTRE | 0 | +7.568 | +7.732 | C8'/CA-CB | A71 | 40
POUTRE | 0 | +7.692 | +7.851 | C8'/CA-CB | A70 | 40
POUTRE | 0 | +7.692 | +7.851 | C7/CA-CB | A70 | 40
POUTRE | 0 | +7.692 | +7.851 | C5/CA-CB | A69 | 40
POTEAU | 0 | -0.200 | +8.550 | C7/CA | PT10 | 334.997
LONGERON | 0 | +7.950 | +8.100 | C4/CA-CB | L34 | 70
3 x ATTACHE | 0 | +7.880 | +7.950 | C4/CA-CB | A37 | 70
3 x ATTACHE | 0 | +7.880 | +7.950 | C6/CA-CB | A37 | 70
LONGERON | 0 | +7.950 | +8.100 | C6/CA-CB | L35 | 70
3 x ATTACHE | 0 | +7.880 | +7.950 | C8/CA-CB | A37 | 70
LONGERON | 0 | +7.950 | +8.100 | C8/CA-CB | L36 | 70
ATTACHE | 0 | +7.880 | +7.950 | C6/CA | A31 | 70
ATTACHE | 0 | +7.907 | +8.073 | C9/CB | A67 | 160.219
ATTACHE | 0 | +8.290 | +8.450 | C9/CB | A5 | 130
LISSE ACROTERE | 0 | +8.450 | +8.550 | C9/CA-CB | L47 | 100
STABILITE CVT | 0 | +7.375 | +7.538 | C1-C2/CA-CB | S38 | 50
STABILITE CVT | 0 | +7.378 | +7.483 | C1-C2/CA-CB | S9 | 50
2 x ATTACHE | 0 | +7.410 | +7.532 | C2/CB | A54 | 70
2 x ATTACHE | 0 | +7.412 | +7.535 | C2/CB | A53 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C7-C9/CA | L14 | 100
2 x ATTACHE | 0 | +8.450 | +8.550 | C8-C8'/CA | A52 | 100
MONTANT | 0 | +7.940 | +8.360 | C6-C7/CA | M20 | 200
MONTANT | 0 | +7.940 | +8.360 | C4-C5/CA | M20 | 200
TRAVERSE | 0 | +7.297 | +8.039 | C9/CA-CB | T3 | 190
TRAVERSE | 0 | +7.017 | +8.049 | C7/CA-CB | T4 | 210
ATTACHE | 0 | +7.950 | +8.100 | C4/CA | A26 | 60
ATTACHE | 0 | +7.950 | +8.100 | C8/CA | A26 | 60
ATTACHE | 0 | +7.950 | +8.100 | C6/CA | A26 | 60
TRAVERSE | 0 | +7.017 | +8.047 | C5/CA-CB | T5 | 210
PLAQUETTE | 0 | +7.674 | +7.734 | C4-C5/CA | P1 | 8
6 x MAIN COURANTE | 0 |  |  |  | MC1 | 60
4 x GOUSSET | 0 | +9.780 | +9.996 | C6-C7/CA-CB | G17 | 6
GOUSSET | 0 | +8.582 | +8.719 | C7/CA | G15 | 6
4 x STABILITE CVT | 0 | +8.589 | +9.892 | C6-C7/CA-CB | S7 | 60
3 x SUSPENTE | 0 | +8.240 | +9.761 | C8-C8'/CA-CB | S22 | 192.866
3 x SUSPENTE | 0 | +8.240 | +10.541 | C6-C7/CA-CB | S21 | 191.054
3 x SUSPENTE | 0 | +8.240 | +11.290 | C4-C5/CA-CB | S20 | 190.713
3 x SOLIVE | 0 | +7.985 | +8.045 | C8-C8'/CA-CB | S18 | 60
3 x SOLIVE | 0 | +7.985 | +8.045 | C6-C7/CA-CB | S18 | 60
3 x SOLIVE | 0 | +7.985 | +8.045 | C4-C5/CA-CB | S18 | 60
SUPPORT | 0 | +8.050 | +8.100 | C4-C5/CA-CB | S37 | 50
SUPPORT | 0 | +8.050 | +8.100 | C4-C5/CA-CB | S13 | 50
SUPPORT | 0 | +8.050 | +8.100 | C8-C8'/CA-CB | S37 | 50
SUPPORT | 0 | +8.050 | +8.100 | C8-C8'/CA-CB | S13 | 50
SUPPORT | 0 | +8.050 | +8.100 | C6-C7/CA-CB | S37 | 50
SUPPORT | 0 | +8.050 | +8.100 | C6-C7/CA-CB | S13 | 50
SOLIVE | 0 | +7.985 | +8.045 | C8-C8'/CB | S18 | 60
SOLIVE | 0 | +7.985 | +8.045 | C6-C7/CB | S18 | 60
ATTACHE | 0 | +7.880 | +7.950 | C8/CB | A37 | 70
LONGERON | 0 | +7.950 | +8.100 | C8/CA-CB | L72 | 70
ATTACHE | 0 | +7.880 | +7.950 | C6/CB | A37 | 70
LONGERON | 0 | +7.950 | +8.100 | C6/CA-CB | L72 | 70
SOLIVE | 0 | +7.985 | +8.045 | C4-C5/CB | S18 | 60
LONGERON | 0 | +7.950 | +8.100 | C4/CA-CB | L72 | 70
ATTACHE | 0 | +7.880 | +7.950 | C4/CB | A37 | 70
FEUILLURE | 0 | +8.570 | +11.860 | C6-C8/CA | F19 | 70
FEUILLURE | 0 | +8.570 | +11.037 | C8-C9/CA | F20 | 70
FEUILLURE | 0 | +8.567 | +12.662 | C4-C6/CA | F16 | 70
POTEAU | 0 | -0.200 | +8.450 | C8/CA | PT3 | 310
ATTACHE | 0 | +8.350 | +8.450 | C7-C8/CA | A50 | 100
LISSE CHASSIS | 0 | +7.100 | +7.200 | C1/CA-CB | L61 | 100
ATTACHE | 0 | +7.100 | +7.200 | C1/CB | A30 | 70
LISSE CHASSIS | 0 | +2.760 | +2.860 | C1/CA-CB | L18 | 170
ATTACHE | 0 | +2.760 | +2.860 | C1/CB | A30 | 70
LISSE CHASSIS | 0 | +4.450 | +4.550 | C1/CA-CB | L61 | 100
ATTACHE | 0 | +4.450 | +4.550 | C1/CB | A30 | 70
LISSE CHASSIS | 0 | +7.100 | +7.200 | C1/CA-CB | L50 | 100
ATTACHE | 0 | +7.100 | +7.200 | C1/CA | A30 | 70
LISSE CHASSIS | 0 | +2.760 | +2.860 | C1/CA-CB | L20 | 170
ATTACHE | 0 | +2.760 | +2.860 | C1/CA | A30 | 70
LISSE CHASSIS | 0 | +4.450 | +4.550 | C1/CA-CB | L60 | 100
ATTACHE | 0 | +4.450 | +4.550 | C1/CA | A30 | 70
ATTACHE | 0 | +4.550 | +4.620 | C1/CA | A30 | 70
ATTACHE | 0 | +4.380 | +4.450 | C1/CA | A30 | 70
MONTANT | 0 | +4.555 | +7.095 | C1/CA-CB | M9 | 100
ATTACHE | 0 | +2.860 | +2.930 | C1/CA | A30 | 70
MONTANT | 0 | +2.865 | +4.445 | C1/CA-CB | M35 | 100
ATTACHE | 0 | +7.030 | +7.100 | C1/CA | A30 | 70
SUPPORT | 0 | +7.860 | +7.930 | C1/CA-CB | S17 | 69.9655
SUPPORT | 0 | +7.860 | +7.932 | C1/CA-CB | S19 | 50.1324
SUPPORT | 0 | +7.741 | +7.811 | C1/CA-CB | S17 | 69.9655
SUPPORT | 0 | +7.741 | +7.813 | C1/CA-CB | S19 | 50.1324
SUPPORT | 0 | +7.622 | +7.692 | C1/CA-CB | S17 | 69.9655
SUPPORT | 0 | +7.622 | +7.693 | C1/CA-CB | S19 | 50.1324
RAMASSE PANNE | 0 | +7.531 | +7.856 | C1/CA-CB | RP1 | 80
RAMASSE PANNE | 0 | +7.289 | +7.611 | C1/CA-CB | RP2 | 80
2 x ATTACHE | 0 | +7.768 | +7.852 | C1/CA | A15 | 80
2 x ATTACHE | 0 | +7.290 | +7.374 | C1/CB | A15 | 80
BAIONNETTE | 0 | +7.535 | +8.445 | C1/CA-CB | B8 | 50
CALE | 0 | +8.083 | +8.183 | C1/CA-CB | C2 | 6
CALE | 0 | +8.202 | +8.302 | C1/CA-CB | C2 | 6
3 x CALE | 0 | +8.350 | +8.445 | C1/CA-CB | C1 | 6
4 x ATTACHE | 0 | +8.350 | +8.450 | C1/CA-CB | A46 | 100
BAIONNETTE | 0 | +7.655 | +8.445 | C1/CA-CB | B10 | 50
BAIONNETTE | 0 | +7.775 | +8.445 | C1/CA-CB | B12 | 50
ATTACHE | 0 | +8.386 | +8.450 | C1/CA-CB | A62 | 64.0839
ATTACHE | 0 | +7.907 | +8.073 | C1/CB | A67 | 160.219
ATTACHE | 0 | +8.083 | +8.193 | C1/CA-CB | A66 | 176.932
ATTACHE | 0 | +8.083 | +8.199 | C1/CA-CB | A65 | 110.386
ATTACHE | 0 | +8.202 | +8.312 | C1/CA-CB | A66 | 176.941
ATTACHE | 0 | +8.202 | +8.318 | C1/CA-CB | A65 | 110.386
LISSE ACROTERE | 0 | +8.450 | +8.550 | C1/CA-CB | L6 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C1/CA-CB | L49 | 100
ATTACHE | 0 | +7.633 | +7.763 | C1/CA | A4 | 129.936
ATTACHE | 0 | +7.172 | +7.306 | C1/CB | A3 | 130.25
CALE | 0 | +8.350 | +8.445 | C1/CA | C3 | 8
LISSE ACROTERE | 0 | +8.450 | +8.550 | C9/CA-CB | L48 | 100
ATTACHE | 0 | +8.350 | +8.450 | C9/CA | A49 | 100
ATTACHE | 0 | +8.350 | +8.450 | C9/CA | A46 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C1-C2/CA | L7 | 100
ATTACHE | 0 | +8.350 | +8.450 | C1/CA | A48 | 100
ATTACHE | 0 | +8.350 | +8.450 | C1/CA | A46 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C2-C4/CA | L46 | 100
ATTACHE | 0 | +8.350 | +8.450 | C3-C4/CA | A47 | 100
ATTACHE | 0 | +8.350 | +8.450 | C3/CA | A46 | 100
2 x ATTACHE | 0 | +8.350 | +8.450 | C2/CA | A46 | 100
4 x ATTACHE | 0 | +8.350 | +8.450 | C9/CA-CB | A46 | 100
ATTACHE | 0 | +8.386 | +8.450 | C9/CA-CB | A62 | 64.0839
ATTACHE | 0 | +8.083 | +8.193 | C9/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.083 | +8.199 | C9/CA-CB | A63 | 110.244
ATTACHE | 0 | +8.202 | +8.312 | C9/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.202 | +8.318 | C9/CA-CB | A63 | 110.244
ATTACHE | 0 | +7.964 | +8.079 | C8'/CB | A63 | 110.244
ATTACHE | 0 | +8.083 | +8.193 | C8'/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.083 | +8.199 | C8'/CA-CB | A63 | 110.244
ATTACHE | 0 | +8.202 | +8.312 | C8'/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.202 | +8.318 | C8'/CA-CB | A63 | 110.244
ATTACHE | 0 | +8.386 | +8.450 | C8'/CA-CB | A62 | 64.0839
LISSE ACROTERE | 0 | +8.450 | +8.550 | C8'/CA-CB | L45 | 100
ATTACHE | 0 | +7.964 | +8.079 | C7/CB | A63 | 110.244
ATTACHE | 0 | +8.083 | +8.193 | C7/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.083 | +8.199 | C7/CA-CB | A63 | 110.244
ATTACHE | 0 | +8.202 | +8.312 | C7/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.202 | +8.318 | C7/CA-CB | A63 | 110.244
ATTACHE | 0 | +8.386 | +8.450 | C7/CA-CB | A62 | 64.0839
LISSE ACROTERE | 0 | +8.450 | +8.550 | C7/CA-CB | L13 | 100
ATTACHE | 0 | +8.386 | +8.450 | C5/CA-CB | A62 | 64.0839
LISSE ACROTERE | 0 | +8.450 | +8.550 | C5/CA-CB | L10 | 100
ATTACHE | 0 | +7.964 | +8.079 | C5/CB | A63 | 110.244
ATTACHE | 0 | +8.083 | +8.193 | C5/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.083 | +8.199 | C5/CA-CB | A63 | 110.244
ATTACHE | 0 | +8.202 | +8.312 | C5/CA-CB | A64 | 181.441
ATTACHE | 0 | +8.202 | +8.318 | C5/CA-CB | A63 | 110.244
4 x GOUSSET | 0 | +9.412 | +9.550 | C8-C8'/CA-CB | G27 | 6
4 x ATTACHE | 0 | +9.391 | +9.511 | C8-C8'/CA-CB | A27 | 60
GOUSSET | 0 | +8.553 | +8.625 | C8'/CB | G18 | 6
ATTACHE | 0 | +8.499 | +8.619 | C8'/CB | A27 | 60
2 x GOUSSET | 0 | +8.553 | +8.625 | C8'/CA-CB | G18 | 6
GOUSSET | 0 | +8.553 | +8.625 | C8'/CA | G18 | 6
2 x ATTACHE | 0 | +8.499 | +8.619 | C8'/CA-CB | A27 | 60
ATTACHE | 0 | +8.499 | +8.619 | C8'/CA | A27 | 60
ATTACHE | 0 | +10.283 | +10.403 | C8/CB | A27 | 60
GOUSSET | 0 | +10.337 | +10.408 | C8/CB | G18 | 6
2 x ATTACHE | 0 | +10.283 | +10.403 | C8/CA-CB | A27 | 60
2 x GOUSSET | 0 | +10.337 | +10.408 | C8/CA-CB | G18 | 6
GOUSSET | 0 | +10.337 | +10.408 | C8/CA | G18 | 6
4 x STABILITE CVT | 0 | +9.504 | +10.439 | C8-C8'/CA-CB | S8 | 50
4 x STABILITE CVT | 0 | +8.572 | +9.490 | C8-C8'/CA-CB | S8 | 50
ATTACHE | 0 | +10.283 | +10.403 | C8/CA | A27 | 60
ATTACHE | 0 | +8.504 | +8.640 | C7/CB | A28 | 60
GOUSSET | 0 | +8.557 | +8.664 | C7/CB | G14 | 6
2 x ATTACHE | 0 | +8.504 | +8.640 | C7/CA-CB | A28 | 60
2 x GOUSSET | 0 | +8.557 | +8.664 | C7/CA-CB | G14 | 6
ATTACHE | 0 | +8.578 | +8.714 | C7/CA | A28 | 60
ATTACHE | 0 | +11.078 | +11.214 | C6/CB | A28 | 60
GOUSSET | 0 | +11.113 | +11.219 | C6/CB | G14 | 6
2 x ATTACHE | 0 | +11.078 | +11.214 | C6/CA-CB | A28 | 60
2 x GOUSSET | 0 | +11.113 | +11.219 | C6/CA-CB | G14 | 6
GOUSSET | 0 | +11.113 | +11.219 | C6/CA | G14 | 6
4 x STABILITE CVT | 0 | +9.923 | +11.247 | C6-C7/CA-CB | S7 | 60
ATTACHE | 0 | +11.078 | +11.214 | C6/CA | A28 | 60
ATTACHE | 0 | +9.803 | +9.925 | C6-C7/CA | A68 | 60
2 x ATTACHE | 0 | +9.803 | +9.925 | C6-C7/CA-CB | A68 | 60
ATTACHE | 0 | +9.803 | +9.925 | C6-C7/CB | A68 | 60
4 x ATTACHE | 0 | +9.791 | +9.927 | C6-C7/CA-CB | A28 | 60
4 x BUTON | 0 | +9.882 | +9.936 | C6-C7/CA-CB | B13 | 40
4 x GOUSSET | 0 | +10.143 | +10.400 | C4-C5/CA-CB | G16 | 6
4 x BUTON | 0 | +10.265 | +10.319 | C4-C5/CA-CB | B13 | 40
ATTACHE | 0 | +10.186 | +10.309 | C4-C5/CA | A68 | 60
2 x ATTACHE | 0 | +10.186 | +10.309 | C4-C5/CA-CB | A68 | 60
ATTACHE | 0 | +10.186 | +10.309 | C4-C5/CB | A68 | 60
GOUSSET | 0 | +11.894 | +11.997 | C4/CB | G12 | 6
2 x GOUSSET | 0 | +11.894 | +11.997 | C4/CA-CB | G12 | 6
2 x GOUSSET | 0 | +8.546 | +8.649 | C5/CA-CB | G12 | 6
GOUSSET | 0 | +8.562 | +8.714 | C5/CA | G13 | 6
GOUSSET | 0 | +11.894 | +11.997 | C4/CA | G12 | 6
ATTACHE | 0 | +8.572 | +8.708 | C5/CA | A28 | 60
ATTACHE | 0 | +11.855 | +11.992 | C4/CA | A28 | 60
2 x ATTACHE | 0 | +11.855 | +11.992 | C4/CA-CB | A28 | 60
2 x ATTACHE | 0 | +8.493 | +8.630 | C5/CA-CB | A28 | 60
ATTACHE | 0 | +11.855 | +11.992 | C4/CB | A28 | 60
4 x ATTACHE | 0 | +10.174 | +10.311 | C4-C5/CA-CB | A28 | 60
4 x STABILITE CVT | 0 | +8.568 | +10.263 | C4-C5/CA-CB | S6 | 60
4 x STABILITE CVT | 0 | +10.321 | +12.034 | C4-C5/CA-CB | S6 | 60
MONTANT | 0 | -0.095 | +2.755 | C1/CA-CB | M16 | 100
ATTACHE | 0 | -0.100 | -0.030 | C1/CA-CB | A36 | 70
ATTACHE | 0 | +2.690 | +2.760 | C1/CA-CB | A30 | 70
ATTACHE | 0 | +8.350 | +8.450 | C7/CA | A56 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C7/CA-CB | L11 | 100
ATTACHE | 0 | +8.440 | +8.510 | C5/CA | A57 | 70
LISSE ACROTERE | 0 | +8.450 | +8.550 | C5/CA-CB | L9 | 100
ATTACHE | 0 | +8.350 | +8.450 | C8'/CB | A46 | 100
ATTACHE | 0 | +8.350 | +8.450 | C8'/CA | A46 | 100
3 x LISSE ACROTERE | 0 | +8.450 | +8.550 | C8'/CA-CB | L12 | 100
6 x ATTACHE | 0 | +8.350 | +8.450 | C8'/CA-CB | A46 | 100
ATTACHE | 0 | +8.350 | +8.450 | C7/CB | A46 | 100
2 x LISSE ACROTERE | 0 | +8.450 | +8.550 | C7/CA-CB | L64 | 100
6 x ATTACHE | 0 | +8.350 | +8.450 | C7/CA-CB | A46 | 100
ATTACHE | 0 | +8.350 | +8.450 | C5/CB | A46 | 100
2 x LISSE ACROTERE | 0 | +8.450 | +8.550 | C5/CA-CB | L64 | 100
6 x ATTACHE | 0 | +8.350 | +8.450 | C5/CA-CB | A46 | 100
TRAVERSE SHED | 0 | +8.550 | +12.167 | C4-C5/CA | TS15 | 150
TRAVERSE SHED | 0 | +8.550 | +11.366 | C6-C7/CA | TS5 | 150
TRAVERSE SHED | 0 | +7.928 | +12.167 | C4-C5/CA-CB | TS14 | 150.24
TRAVERSE SHED | 0 | +7.809 | +12.167 | C4-C5/CA-CB | TS11 | 150.24
TRAVERSE SHED | 0 | +7.689 | +12.167 | C4-C5/CA-CB | TS12 | 150.24
TRAVERSE SHED | 0 | +7.570 | +12.167 | C4-C5/CB | TS13 | 150.24
TRAVERSE SHED | 0 | +7.928 | +11.366 | C6-C7/CA-CB | TS1 | 150.24
TRAVERSE SHED | 0 | +7.809 | +11.366 | C6-C7/CA-CB | TS2 | 150.24
TRAVERSE SHED | 0 | +7.689 | +11.366 | C6-C7/CA-CB | TS3 | 150.24
TRAVERSE SHED | 0 | +7.570 | +11.366 | C6-C7/CB | TS4 | 150.24
TRAVERSE SHED | 0 | +8.048 | +10.553 | C8-C8'/CA | TS10 | 140.922
TRAVERSE SHED | 0 | +7.928 | +10.553 | C8-C8'/CA-CB | TS6 | 150.24
TRAVERSE SHED | 0 | +7.809 | +10.553 | C8-C8'/CA-CB | TS7 | 150.24
TRAVERSE SHED | 0 | +7.689 | +10.553 | C8-C8'/CA-CB | TS8 | 150.24
TRAVERSE SHED | 0 | +7.570 | +10.553 | C8-C8'/CB | TS9 | 150.24
ATTACHE | 0 | +8.440 | +8.510 | C6/CA | A57 | 70
LISSE ACROTERE | 0 | +8.450 | +8.550 | C6/CA-CB | L15 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C8/CA-CB | L16 | 100
MONTANT | 0 | +8.450 | +10.980 | C8/CA | M7 | 335.921
ATTACHE | 0 | +8.195 | +8.269 | C8/CA-CB | A35 | 70
ATTACHE | 0 | +8.195 | +8.269 | C6/CA-CB | A35 | 70
ATTACHE | 0 | +8.314 | +8.388 | C4/CA-CB | A35 | 70
ATTACHE | 0 | +8.314 | +8.388 | C8/CA-CB | A35 | 70
ATTACHE | 0 | +8.314 | +8.388 | C6/CA-CB | A35 | 70
LISSE CONTREBARDAGE | 0 | +8.267 | +8.438 | C8/CA-CB | L66 | 50
LISSE CONTREBARDAGE | 0 | +8.147 | +8.316 | C8/CA-CB | L67 | 50
LISSE CONTREBARDAGE | 0 | +8.023 | +8.197 | C8/CA-CB | L71 | 50
MONTANT | 0 | +8.450 | +10.295 | C8/CA | M15 | 105
MONTANT | 0 | +8.450 | +10.295 | C8/CB | M15 | 105
LISSE ACROTERE | 0 | +8.450 | +8.550 | C8/CA-CB | L44 | 100
MONTANT | 0 | +7.250 | +10.980 | C8/CA-CB | M8 | 511.83
MONTANT | 0 | +7.250 | +10.980 | C8/CB | M34 | 355.915
LISSE CONTREBARDAGE | 0 | +8.267 | +8.438 | C6/CA-CB | L66 | 50
LISSE CONTREBARDAGE | 0 | +8.147 | +8.316 | C6/CA-CB | L67 | 50
LISSE CONTREBARDAGE | 0 | +8.023 | +8.197 | C6/CA-CB | L71 | 50
MONTANT | 0 | +8.450 | +11.120 | C6/CA | M14 | 105
MONTANT | 0 | +8.450 | +11.120 | C6/CB | M14 | 105
LISSE ACROTERE | 0 | +8.450 | +8.550 | C6/CA-CB | L44 | 100
MONTANT | 0 | +7.250 | +11.800 | C6/CA-CB | M6 | 471.914
MONTANT | 0 | +7.250 | +11.800 | C6/CB | M33 | 335.957
LISSE ACROTERE | 0 | +10.195 | +10.295 | C8/CA-CB | L17 | 100
LISSE ACROTERE | 0 | +10.195 | +10.295 | C8/CA-CB | L16 | 100
LISSE ACROTERE | 0 | +11.020 | +11.120 | C6/CA-CB | L17 | 100
LISSE ACROTERE | 0 | +11.020 | +11.120 | C6/CA-CB | L16 | 100
MONTANT | 0 | +8.550 | +11.800 | C6/CA | M5 | 335.962
LISSE CONTREBARDAGE | 0 | +8.267 | +8.438 | C4/CA-CB | L66 | 50
LISSE CONTREBARDAGE | 0 | +8.147 | +8.316 | C4/CA-CB | L67 | 50
LISSE CONTREBARDAGE | 0 | +8.023 | +8.197 | C4/CA-CB | L28 | 50
ATTACHE | 0 | +8.195 | +8.269 | C4/CA-CB | A35 | 70
MONTANT | 0 | +8.450 | +11.920 | C4/CA | M13 | 105
MONTANT | 0 | +8.450 | +11.920 | C4/CB | M13 | 105
LISSE ACROTERE | 0 | +11.820 | +11.920 | C4/CA-CB | L17 | 100
LISSE ACROTERE | 0 | +11.820 | +11.920 | C4/CA-CB | L16 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C4/CA-CB | L44 | 100
LISSE ACROTERE | 0 | +8.450 | +8.550 | C4/CA-CB | L8 | 100
ATTACHE | 0 | +8.350 | +8.450 | C4/CA | A56 | 100
MONTANT | 0 | +8.550 | +12.603 | C4/CA | M3 | 317.856
MONTANT | 0 | +7.250 | +12.603 | C4/CA-CB | M4 | 435.7
MONTANT | 0 | +7.250 | +12.603 | C4/CB | M30 | 317.85
2 x ATTACHE | 0 | +7.804 | +8.010 | C8'/CA | A58 | 100
GOUSSET | 0 | +7.465 | +7.573 | C8'-C9/CA-CB | G10 | 64.1569
GOUSSET | 0 | +7.576 | +7.692 | C8'-C9/CA-CB | G9 | 64.1569
GOUSSET | 0 | +7.692 | +7.812 | C8'-C9/CA-CB | G8 | 64.1569
6 x ATTACHE | 0 | +7.100 | +7.220 | C9/CA-CB | A14 | 40
GOUSSET | 0 | +7.100 | +7.265 | C9/CA-CB | G7 | 6
GOUSSET | 0 | +7.100 | +7.285 | C9/CA-CB | G6 | 6
GOUSSET | 0 | +7.100 | +7.304 | C9/CA-CB | G5 | 6
ATTACHE | 0 | +7.838 | +7.922 | C9/CA-CB | A17 | 80
ATTACHE | 0 | +7.600 | +7.683 | C9/CA-CB | A17 | 80
ATTACHE | 0 | +7.719 | +7.803 | C9/CA-CB | A17 | 80
STABILITE CVT | 0 | +7.461 | +7.623 | C8'-C9/CA-CB | S30 | 60
STABILITE CVT | 0 | +7.581 | +7.742 | C8'-C9/CA-CB | S30 | 60
STABILITE CVT | 0 | +7.700 | +7.862 | C8'-C9/CA-CB | S30 | 60
GOUSSET | 0 | +7.445 | +7.465 | C8'/CB | G3 | 6
GOUSSET | 0 | +7.553 | +7.585 | C8'/CA-CB | G1 | 6
GOUSSET | 0 | +7.672 | +7.704 | C8'/CA-CB | G1 | 6
GOUSSET | 0 | +7.792 | +7.824 | C8'/CA-CB | G1 | 6
GOUSSET | 0 | +7.906 | +7.918 | C9/CA-CB | G19 | 6
GOUSSET | 0 | +7.792 | +7.824 | C9/CA-CB | G2 | 6
GOUSSET | 0 | +7.672 | +7.704 | C9/CA-CB | G2 | 6
GOUSSET | 0 | +7.553 | +7.585 | C9/CA-CB | G2 | 6
GOUSSET | 0 | +7.445 | +7.465 | C9/CB | G4 | 6
ATTACHE | 0 | +7.846 | +7.912 | C9/CA-CB | A25 | 60
ATTACHE | 0 | +7.747 | +7.813 | C9/CA-CB | A25 | 60
ATTACHE | 0 | +7.736 | +7.802 | C9/CA-CB | A25 | 60
ATTACHE | 0 | +7.627 | +7.694 | C9/CA-CB | A25 | 60
ATTACHE | 0 | +7.617 | +7.683 | C9/CA-CB | A25 | 60
ATTACHE | 0 | +7.508 | +7.574 | C9/CA-CB | A25 | 60
ATTACHE | 0 | +7.497 | +7.564 | C9/CA-CB | A25 | 60
ATTACHE | 0 | +7.389 | +7.455 | C9/CB | A25 | 60
ATTACHE | 0 | +7.846 | +7.912 | C8'/CA-CB | A25 | 60
ATTACHE | 0 | +7.747 | +7.813 | C8'/CA-CB | A25 | 60
ATTACHE | 0 | +7.736 | +7.802 | C8'/CA-CB | A25 | 60
ATTACHE | 0 | +7.627 | +7.694 | C8'/CA-CB | A25 | 60
ATTACHE | 0 | +7.617 | +7.683 | C8'/CA-CB | A25 | 60
ATTACHE | 0 | +7.508 | +7.574 | C8'/CA-CB | A25 | 60
ATTACHE | 0 | +7.497 | +7.564 | C8'/CA-CB | A25 | 60
ATTACHE | 0 | +7.389 | +7.455 | C8'/CB | A25 | 60
ATTACHE | 0 | +7.810 | +8.013 | C9/CA | A59 | 100
ATTACHE | 0 | +7.807 | +8.010 | C9/CA | A59 | 100
ATTACHE | 0 | +7.810 | +8.013 | C8/CA | A42 | 80
ATTACHE | 0 | +7.807 | +8.010 | C8/CA | A43 | 80
ATTACHE | 0 | +7.470 | +7.532 | C9/CB | A61 | 70
ATTACHE | 0 | +7.472 | +7.536 | C9/CB | A60 | 100
ATTACHE | 0 | +7.588 | +7.652 | C9/CA-CB | A60 | 100
ATTACHE | 0 | +7.592 | +7.655 | C9/CA-CB | A60 | 100
ATTACHE | 0 | +7.708 | +7.771 | C9/CA-CB | A60 | 100
ATTACHE | 0 | +7.711 | +7.774 | C9/CA-CB | A60 | 100
ATTACHE | 0 | +7.827 | +7.890 | C9/CA-CB | A60 | 100
ATTACHE | 0 | +7.831 | +7.894 | C9/CA-CB | A60 | 100
ATTACHE | 0 | +7.469 | +7.532 | C8'/CB | A60 | 100
ATTACHE | 0 | +7.472 | +7.536 | C8'/CB | A60 | 100
ATTACHE | 0 | +7.588 | +7.652 | C8'/CA-CB | A60 | 100
ATTACHE | 0 | +7.592 | +7.655 | C8'/CA-CB | A60 | 100
ATTACHE | 0 | +7.827 | +7.890 | C8'/CA-CB | A60 | 100
ATTACHE | 0 | +7.831 | +7.894 | C8'/CA-CB | A60 | 100
ATTACHE | 0 | +7.708 | +7.771 | C8'/CA-CB | A60 | 100
ATTACHE | 0 | +7.711 | +7.774 | C8'/CA-CB | A60 | 100
ATTACHE | 0 | +7.890 | +8.013 | C8/CA | A41 | 80
ATTACHE | 0 | +7.887 | +8.010 | C8/CA | A41 | 80
ATTACHE | 0 | +7.887 | +8.010 | C7/CA | A40 | 80
ATTACHE | 0 | +7.890 | +8.013 | C7/CA | A40 | 80
ATTACHE | 0 | +7.768 | +7.890 | C8/CA-CB | A38 | 80
ATTACHE | 0 | +7.771 | +7.893 | C8/CA-CB | A38 | 80
ATTACHE | 0 | +7.649 | +7.771 | C8/CA-CB | A38 | 80
ATTACHE | 0 | +7.651 | +7.774 | C8/CA-CB | A38 | 80
ATTACHE | 0 | +7.410 | +7.532 | C8/CB | A38 | 80
ATTACHE | 0 | +7.412 | +7.535 | C8/CB | A38 | 80
ATTACHE | 0 | +7.529 | +7.652 | C8/CA-CB | A38 | 80
ATTACHE | 0 | +7.532 | +7.654 | C8/CA-CB | A38 | 80
ATTACHE | 0 | +7.767 | +7.890 | C7/CA-CB | A55 | 100
ATTACHE | 0 | +7.771 | +7.894 | C7/CA-CB | A55 | 100
ATTACHE | 0 | +7.409 | +7.532 | C7/CB | A55 | 100
ATTACHE | 0 | +7.412 | +7.535 | C7/CB | A55 | 100
ATTACHE | 0 | +7.528 | +7.652 | C7/CA-CB | A55 | 100
ATTACHE | 0 | +7.532 | +7.655 | C7/CA-CB | A55 | 100
ATTACHE | 0 | +7.648 | +7.771 | C7/CA-CB | A55 | 100
ATTACHE | 0 | +7.651 | +7.774 | C7/CA-CB | A55 | 100
ATTACHE | 0 | +7.889 | +8.012 | C5/CA | A55 | 100
ATTACHE | 0 | +7.892 | +8.016 | C5/CA | A55 | 100
ATTACHE | 0 | +7.419 | +7.542 | C5/CB | A55 | 100
ATTACHE | 0 | +7.422 | +7.545 | C5/CB | A55 | 100
ATTACHE | 0 | +7.538 | +7.662 | C5/CA-CB | A55 | 100
ATTACHE | 0 | +7.542 | +7.665 | C5/CA-CB | A55 | 100
ATTACHE | 0 | +7.658 | +7.781 | C5/CA-CB | A55 | 100
ATTACHE | 0 | +7.661 | +7.784 | C5/CA-CB | A55 | 100
ATTACHE | 0 | +7.777 | +7.900 | C5/CA-CB | A55 | 100
ATTACHE | 0 | +7.781 | +7.904 | C5/CA-CB | A55 | 100
ATTACHE | 0 | +7.890 | +8.012 | C6/CA | A38 | 80
ATTACHE | 0 | +7.892 | +8.015 | C6/CA | A38 | 80
ATTACHE | 0 | +7.778 | +7.900 | C6/CA-CB | A38 | 80
ATTACHE | 0 | +7.781 | +7.903 | C6/CA-CB | A38 | 80
ATTACHE | 0 | +7.420 | +7.542 | C6/CB | A38 | 80
ATTACHE | 0 | +7.422 | +7.545 | C6/CB | A38 | 80
ATTACHE | 0 | +7.539 | +7.662 | C6/CA-CB | A38 | 80
ATTACHE | 0 | +7.542 | +7.664 | C6/CA-CB | A38 | 80
ATTACHE | 0 | +7.659 | +7.781 | C6/CA-CB | A38 | 80
ATTACHE | 0 | +7.661 | +7.784 | C6/CA-CB | A38 | 80
2 x ATTACHE | 0 | +7.143 | +7.224 | C8/CA-CB | A51 | 100
ATTACHE | 0 | +7.017 | +7.117 | C8/CA | A24 | 100
2 x ATTACHE | 0 | +7.104 | +7.225 | C6/CA | A23 | 100
ATTACHE | 0 | +6.979 | +7.079 | C6/CA | A19 | 100
2 x ATTACHE | 0 | +7.090 | +7.220 | C4/CA | A22 | 100
ATTACHE | 0 | +6.960 | +7.060 | C4/CA | A19 | 100
MONTANT | 0 | +7.250 | +10.980 | C8/CA-CB | M29 | 511.83
MONTANT | 0 | +7.250 | +10.980 | C8/CA-CB | M27 | 511.83
2 x ECLISSE | 0 | +7.139 | +7.229 | C8/CA-CB | E1 | 10
ECLISSE | 0 | +7.107 | +7.117 | C8/CA-CB | E4 | 10
LONGERON | 0 | +7.117 | +7.250 | C8/CA-CB | L43 | 140
MONTANT | 0 | +7.250 | +11.800 | C6/CA-CB | M28 | 471.914
ECLISSE | 0 | +7.069 | +7.079 | C6/CA-CB | E4 | 10
2 x ECLISSE | 0 | +7.105 | +7.225 | C6/CA-CB | E3 | 10
MONTANT | 0 | +7.250 | +11.800 | C6/CA-CB | M26 | 471.914
LONGERON | 0 | +7.079 | +7.250 | C6/CA-CB | L42 | 180
2 x ECLISSE | 0 | +7.095 | +7.215 | C4/CA-CB | E3 | 10
ECLISSE | 0 | +7.050 | +7.060 | C4/CA-CB | E4 | 10
MONTANT | 0 | +7.250 | +12.603 | C4/CA-CB | M24 | 435.701
LONGERON | 0 | +7.060 | +7.250 | C4/CA-CB | L41 | 200
MONTANT | 0 | +7.250 | +12.603 | C4/CA-CB | M25 | 435.701
2 x ECLISSE | 0 | +8.395 | +8.515 | C5-C6/CA | E3 | 10
ECLISSE | 0 | +8.550 | +8.560 | C5-C6/CA | E2 | 10
MONTANT | 0 | +5.190 | +8.360 | C5-C6/CA | M23 | 410
2 x ECLISSE | 0 | +5.035 | +5.155 | C5-C6/CA | E3 | 10
ECLISSE | 0 | +4.990 | +5.000 | C5-C6/CA | E2 | 10
MONTANT | 0 | +5.190 | +8.360 | C5/CA | M19 | 439.383
MONTANT | 0 | +5.190 | +8.360 | C4-C5/CA | M31 | 487.245
2 x ATTACHE | 0 | +8.390 | +8.520 | C4/CA | A22 | 100
ATTACHE | 0 | +8.119 | +8.360 | C4/CA | A20 | 239.383
TRAVERSE HAUTE | 0 | +8.360 | +8.550 | C4-C6/CA | TH2 | 200
MONTANT | 0 | +5.190 | +8.360 | C6-C7/CA | M32 | 438.352
MONTANT | 0 | +5.190 | +8.360 | C6/CA | M22 | 416.951
2 x ATTACHE | 0 | +5.030 | +5.160 | C7/CA | A22 | 100
ATTACHE | 0 | +4.900 | +5.000 | C7/CA | A19 | 100
TRAVERSE BASSE | 0 | +5.000 | +5.190 | C5-C7/CA | TB2 | 200
ATTACHE | 0 | +8.097 | +8.360 | C7/CA | A21 | 213.193
6 x ATTACHE | 0 | +2.660 | +2.760 | C1/CA-CB | A44 | 100
2 x LISSE CHASSIS | 0 | +2.760 | +2.860 | C1/CA-CB | L4 | 170
6 x ATTACHE | 0 | +4.350 | +4.450 | C1/CA-CB | A44 | 100
2 x LISSE CHASSIS | 0 | +4.450 | +4.550 | C1/CA-CB | L19 | 100
6 x ATTACHE | 0 | +7.000 | +7.100 | C1/CA-CB | A44 | 100
2 x LISSE CHASSIS | 0 | +7.100 | +7.200 | C1/CA-CB | L19 | 100
2 x ATTACHE | 0 | +8.390 | +8.520 | C7/CA | A22 | 100
2 x ATTACHE | 0 | +5.030 | +5.160 | C4/CA | A22 | 100
ATTACHE | 0 | +4.900 | +5.000 | C4/CA | A19 | 100
ATTACHE | 0 | +0.930 | +1.000 | C7/CA | A34 | 70
LISSE CHASSIS | 0 | +1.000 | +1.100 | C7-C8/CA | L24 | 170
ATTACHE | 0 | +7.030 | +7.100 | C7/CA | A34 | 70
LISSE CHASSIS | 0 | +7.100 | +7.200 | C7-C8/CA | L59 | 100
ATTACHE | 0 | +2.730 | +2.800 | C7/CA | A34 | 70
LISSE CHASSIS | 0 | +2.800 | +2.900 | C7-C8/CA | L57 | 100
ATTACHE | 0 | +4.830 | +4.900 | C7/CA | A34 | 70
LISSE CHASSIS | 0 | +4.900 | +5.000 | C7-C8/CA | L58 | 170
ATTACHE | 0 | +2.690 | +2.760 | C4/CA | A33 | 70
LISSE CHASSIS | 0 | +2.760 | +2.860 | C3-C4/CA | L23 | 170
LISSE CHASSIS | 0 | +4.940 | +5.040 | C3-C4/CA | L54 | 100
ATTACHE | 0 | +0.900 | +1.000 | C1/CA | A44 | 100
LISSE CHASSIS | 0 | +1.000 | +1.100 | C1-C2/CA | L21 | 170
ATTACHE | 0 | +2.700 | +2.800 | C1/CA | A44 | 100
LISSE CHASSIS | 0 | +2.800 | +2.900 | C1-C2/CA | L51 | 100
ATTACHE | 0 | +4.800 | +4.900 | C1/CA | A44 | 100
LISSE CHASSIS | 0 | +4.900 | +5.000 | C1-C2/CA | L52 | 170
ATTACHE | 0 | +7.000 | +7.100 | C1/CA | A44 | 100
LISSE CHASSIS | 0 | +7.100 | +7.200 | C1-C2/CA | L53 | 100
MONTANT | 0 | +5.005 | +7.095 | C7-C8/CA | M10 | 100
ATTACHE | 0 | +5.000 | +5.070 | C7-C8/CA | A32 | 70
ATTACHE | 0 | +7.030 | +7.100 | C7-C8/CA | A32 | 70
MONTANT | 0 | +1.105 | +2.795 | C7-C8/CA | M11 | 100
ATTACHE | 0 | +1.100 | +1.170 | C7-C8/CA | A32 | 70
ATTACHE | 0 | +2.730 | +2.800 | C7-C8/CA | A32 | 70
MONTANT | 0 | +2.865 | +4.935 | C8'/CA | M12 | 100
ATTACHE | 0 | +4.870 | +4.940 | C8'/CA | A32 | 70
LISSE CHASSIS | 0 | +4.940 | +5.040 | C8-C9/CA | L62 | 100
ATTACHE | 0 | +2.900 | +2.970 | C8-C8'/CA | A32 | 70
LISSE CHASSIS | 0 | +2.800 | +2.900 | C8-C8'/CA | L30 | 100
ATTACHE | 0 | +4.870 | +4.940 | C8-C8'/CA | A32 | 70
MONTANT | 0 | +1.105 | +2.795 | C1-C2/CA | M11 | 100
ATTACHE | 0 | +2.730 | +2.800 | C1-C2/CA | A32 | 70
ATTACHE | 0 | +1.100 | +1.170 | C1-C2/CA | A32 | 70
MONTANT | 0 | +2.865 | +4.935 | C3-C4/CA | M12 | 100
ATTACHE | 0 | +4.870 | +4.940 | C3-C4/CA | A32 | 70
ATTACHE | 0 | +2.860 | +2.930 | C3-C4/CA | A32 | 70
MONTANT | 0 | +5.005 | +7.095 | C1-C2/CA | M10 | 100
ATTACHE | 0 | +5.000 | +5.070 | C1-C2/CA | A32 | 70
ATTACHE | 0 | +7.030 | +7.100 | C1-C2/CA | A32 | 70
MONTANT | 0 | +5.005 | +7.095 | C2-C3/CA | M10 | 100
ATTACHE | 0 | +5.000 | +5.070 | C2-C3/CA | A32 | 70
LISSE CHASSIS | 0 | +7.100 | +7.200 | C2-C3/CA | L56 | 100
ATTACHE | 0 | +7.030 | +7.100 | C2-C3/CA | A32 | 70
ATTACHE | 0 | +0.900 | +1.000 | C9/CA | A44 | 100
ATTACHE | 0 | +7.000 | +7.100 | C8/CA | A44 | 100
ATTACHE | 0 | +4.800 | +4.900 | C8/CA | A44 | 100
2 x ATTACHE | 0 | +2.700 | +2.800 | C8/CA | A44 | 100
2 x ATTACHE | 0 | +0.900 | +1.000 | C8/CA | A44 | 100
2 x ATTACHE | 0 | +0.900 | +1.000 | C2/CA | A44 | 100
2 x ATTACHE | 0 | +2.700 | +2.800 | C2/CA | A44 | 100
LISSE CHASSIS | 0 | +2.800 | +2.900 | C2-C3/CA | L22 | 100
2 x ATTACHE | 0 | +4.800 | +4.900 | C2/CA | A44 | 100
2 x ATTACHE | 0 | +7.000 | +7.100 | C2/CA | A44 | 100
ATTACHE | 0 | +0.900 | +1.000 | C3/CA | A44 | 100
ATTACHE | 0 | +7.000 | +7.100 | C3/CA | A44 | 100
ATTACHE | 0 | +4.800 | +4.900 | C3/CA | A44 | 100
ATTACHE | 0 | +2.660 | +2.760 | C3/CA | A44 | 100
ATTACHE | 0 | +7.887 | +8.010 | C4/CA | A38 | 80
ATTACHE | 0 | +7.890 | +8.013 | C4/CA | A38 | 80
ATTACHE | 0 | +7.768 | +7.890 | C4/CA-CB | A38 | 80
ATTACHE | 0 | +7.771 | +7.893 | C4/CA-CB | A38 | 80
ATTACHE | 0 | +7.649 | +7.771 | C4/CA-CB | A38 | 80
ATTACHE | 0 | +7.651 | +7.774 | C4/CA-CB | A38 | 80
ATTACHE | 0 | +7.410 | +7.532 | C4/CB | A38 | 80
ATTACHE | 0 | +7.412 | +7.535 | C4/CB | A38 | 80
ATTACHE | 0 | +7.768 | +7.890 | C1/CA-CB | A39 | 80
ATTACHE | 0 | +7.771 | +7.893 | C1/CA-CB | A39 | 80
ATTACHE | 0 | +7.649 | +7.771 | C1/CA-CB | A39 | 80
ATTACHE | 0 | +7.651 | +7.774 | C1/CA-CB | A39 | 80
ATTACHE | 0 | +7.529 | +7.652 | C1/CA-CB | A39 | 80
ATTACHE | 0 | +7.532 | +7.654 | C1/CA-CB | A39 | 80
ATTACHE | 0 | +7.529 | +7.652 | C4/CA-CB | A38 | 80
ATTACHE | 0 | +7.532 | +7.654 | C4/CA-CB | A38 | 80
2 x ATTACHE | 0 | +7.410 | +7.532 | C3/CB | A54 | 70
2 x ATTACHE | 0 | +7.412 | +7.535 | C3/CB | A53 | 100
2 x ATTACHE | 0 | +7.887 | +8.010 | C3/CA | A53 | 100
2 x ATTACHE | 0 | +7.890 | +8.013 | C3/CA | A53 | 100
2 x ATTACHE | 0 | +7.528 | +7.652 | C3/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.532 | +7.655 | C3/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.648 | +7.771 | C3/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.651 | +7.774 | C3/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.767 | +7.890 | C3/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.771 | +7.894 | C3/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.887 | +8.010 | C2/CA | A53 | 100
2 x ATTACHE | 0 | +7.890 | +8.013 | C2/CA | A53 | 100
2 x ATTACHE | 0 | +7.528 | +7.652 | C2/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.532 | +7.655 | C2/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.648 | +7.771 | C2/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.651 | +7.774 | C2/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.767 | +7.890 | C2/CA-CB | A53 | 100
2 x ATTACHE | 0 | +7.771 | +7.894 | C2/CA-CB | A53 | 100
4 x LONGERON | 0 | +10.423 | +10.556 | C8/CA-CB | L3 | 140
4 x LONGERON | 0 | +11.236 | +11.369 | C6/CA-CB | L3 | 140
4 x LONGERON | 0 | +12.037 | +12.170 | C4/CA-CB | L3 | 140
2 x LONGERON | 0 |  |  |  | L74 | 0
LONGERON | 0 |  |  |  | L73 | 0
2 x PANNE SHED | 0 | +9.458 | +9.608 | C8-C8'/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +9.487 | +9.637 | C6-C7/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +10.227 | +10.377 | C6-C7/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +10.170 | +10.320 | C8-C8'/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +10.966 | +11.116 | C6-C7/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +11.756 | +11.906 | C4-C5/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +11.004 | +11.154 | C4-C5/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +10.252 | +10.402 | C4-C5/CA-CB | PN35 | 56
2 x PANNE SHED | 0 | +9.500 | +9.650 | C4-C5/CA-CB | PN35 | 56
