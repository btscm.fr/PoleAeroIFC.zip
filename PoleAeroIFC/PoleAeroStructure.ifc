Properties of the parts of a building model (IFC2X3), part 5 of 5

# IfcElementAssembly (1532)
Name | Poids Assemblage/Elément béton (kg) | Niveau Bas Assemblage/Elément béton | Niveau Haut Assemblage/Elément béton | Position maillage Assemblage/Elément béton | Repère Assemblage/Elément béton | Width (mm)
POUTRE | 81 | -0.000 | +0.250 | C1/CB | Po10 | 270 | PredefinedType: REINFORCEMENT_UNIT; Tekla Assemblages - Poids ferraillage Elément béton: 0 kg
FEUILLURE | 0 | +8.570 | +10.850 | C8/CA | F15 | 177.25
FEUILLURE | 0 | +10.120 | +11.670 | C6/CA | F14 | 177.25
FEUILLURE | 0 | +8.570 | +10.120 | C6/CA | F14 | 177.25
FEUILLURE | 0 | +8.570 | +10.520 | C4/CA | F13 | 177.25
FEUILLURE | 0 | +10.520 | +12.470 | C4/CA | F13 | 177.25
STABILITE CVT | 0 | +7.396 | +7.557 | C8'-C9/CA-CB | S30 | 60
STABILITE CVT | 0 | +7.515 | +7.676 | C8'-C9/CA-CB | S30 | 60
STABILITE CVT | 0 | +7.635 | +7.796 | C8'-C9/CA-CB | S30 | 60
TRAVERSE | 0 | +7.117 | +8.039 | C3/CA-CB | T7 | 190
TRAVERSE | 0 | +7.117 | +8.039 | C2/CA-CB | T1 | 190
LISSE CONTREBARDAGE | 0 | +8.030 | +8.195 | C8'/CA-CB | L65 | 50
LISSE CONTREBARDAGE | 0 | +8.149 | +8.314 | C8'/CA-CB | L65 | 50
LISSE CONTREBARDAGE | 0 | +8.268 | +8.429 | C8'/CA-CB | L26 | 50
LISSE CONTREBARDAGE | 0 | +8.029 | +8.195 | C7/CA-CB | L70 | 50
LISSE CONTREBARDAGE | 0 | +8.149 | +8.315 | C7/CA-CB | L70 | 50
LISSE CONTREBARDAGE | 0 | +8.268 | +8.429 | C7/CA-CB | L69 | 50
BAIONNETTE | 0 | +7.690 | +8.445 | C1/CA | B16 | 50
BAIONNETTE | 0 | +7.690 | +8.445 | C1/CA | B6 | 50
SABOT | 0 | +7.000 | +7.565 | C7/CB | S1 | 120.272
PRESCELLEMENT | 0 | +6.970 | +7.625 | C7/CB | PS6 | 122
ATTACHE | 0 | +7.016 | +7.119 | C3/CB | A6 | 100.265
2 x ATTACHE | 0 | +7.203 | +7.483 | C3/CB | A10 | 100
BAIONNETTE | 0 | +7.775 | +8.445 | C1/CA-CB | B11 | 50
BAIONNETTE | 0 | +7.655 | +8.445 | C1/CA-CB | B9 | 50
BAIONNETTE | 0 | +7.535 | +8.445 | C1/CA-CB | B7 | 50
TRAVERSE HAUTE | 0 | +8.360 | +8.550 | C5-C7/CA | TH1 | 200
TRAVERSE BASSE | 0 | +5.000 | +5.190 | C4-C6/CA | TB1 | 200
ATTACHE | 0 | +8.290 | +8.450 | C1/CB | A5 | 130
BAIONNETTE | 0 | +7.100 | +8.445 | C9/CA-CB | B3 | 100
BAIONNETTE | 0 | +7.100 | +8.445 | C9/CA-CB | B2 | 100
BAIONNETTE | 0 | +7.100 | +8.445 | C9/CA-CB | B1 | 100
PRESCELLEMENT | 0 | +7.477 | +7.707 | 3/E | PS5 | 149
2 x ATTACHE | 0 | +7.970 | +8.210 | 7/E | A11 | 100
2 x ATTACHE | 0 | +7.970 | +8.210 | 5/E | A11 | 100
ATTACHE | 0 | +7.970 | +8.210 | C4-C5/CB | A11 | 100
ATTACHE | 0 | +7.970 | +8.210 | 3/E | A11 | 100
SABOT | 0 | +7.092 | +7.272 | C8/CB | S5 | 180
PRESCELLEMENT | 0 | +6.965 | +7.395 | C8/CB | PS4 | 122
SABOT | 0 | +7.054 | +7.274 | C6/CB | S4 | 180
PRESCELLEMENT | 0 | +6.965 | +7.395 | C6/CB | PS4 | 122
SABOT | 0 | +7.035 | +7.275 | C4/CB | S3 | 180
PRESCELLEMENT | 0 | +6.965 | +7.395 | C4/CB | PS4 | 122
SABOT | 0 | +7.100 | +7.565 | C8'/CB | S2 | 120.272
PRESCELLEMENT | 0 | +6.970 | +7.625 | C8'/CB | PS6 | 122
SABOT | 0 | +7.000 | +7.565 | C5/CB | S1 | 120.272
PRESCELLEMENT | 0 | +6.970 | +7.625 | C5/CB | PS6 | 122
ATTACHE | 0 | +7.196 | +7.299 | C9/CB | A7 | 100.265
2 x ATTACHE | 0 | +7.343 | +7.523 | C9/CB | A9 | 100
ATTACHE | 0 | +7.016 | +7.119 | C2/CB | A6 | 100.265
2 x ATTACHE | 0 | +7.203 | +7.483 | C2/CB | A10 | 100
2 x ATTACHE | 0 | +3.255 | +3.375 | C1/CB | A8 | 80
PRESCELLEMENT | 0 | +3.200 | +3.430 | C1/CB | PS3 | 200
2 x LONGERON | 0 |  |  |  | L38 | 0
LONGERON | 0 |  |  |  | L37 | 0
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C1/CB | PS1 | 500
3 x PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C1/CA-CB | PS1 | 500
LISSE | 0 | +1.440 | +1.490 | 6'-6''/A' | L31 | 50
LISSE | 0 | +0.100 | +0.150 | 6'-6''/A' | L31 | 50
TRAVERSE | 0 | +2.674 | +3.045 | 5'/E-A' | T8 | 82
TRAVERSE | 0 | +2.674 | +3.045 | 7'/E-A' | T8 | 82
2 x STABILITE CVT | 0 | +2.846 | +2.977 | 6'-6''/E-A' | S15 | 40
STABILITE CVT | 0 | +7.378 | +7.483 | C3-C4/CA-CB | S40 | 50
STABILITE CVT | 0 | +7.375 | +7.538 | C3-C4/CA-CB | S12 | 50
STABILITE CVT | 0 | +7.378 | +7.483 | C2-C3/CA-CB | S39 | 50
STABILITE CVT | 0 | +7.375 | +7.538 | C2-C3/CA-CB | S11 | 50
STABILITE CVT | 0 | +7.495 | +7.657 | C1-C2/CA-CB | S38 | 50
STABILITE CVT | 0 | +7.497 | +7.602 | C1-C2/CA-CB | S9 | 50
STABILITE CVT | 0 | +7.614 | +7.777 | C1-C2/CA-CB | S38 | 50
STABILITE CVT | 0 | +7.617 | +7.722 | C1-C2/CA-CB | S9 | 50
STABILITE CVT | 0 | +7.733 | +7.896 | C1-C2/CA-CB | S38(?) | 50
STABILITE CVT | 0 | +7.736 | +7.841 | C1-C2/CA-CB | S9 | 50
POTEAU | 0 | -0.180 | +7.370 | C1/CB | PT2 | 270
LISSE CONTREBARDAGE | 0 | +8.023 | +8.195 | C9/CA-CB | L68 | 50
LISSE CONTREBARDAGE | 0 | +8.149 | +8.314 | C9/CA-CB | L65 | 50
LISSE CONTREBARDAGE | 0 | +8.268 | +8.429 | C9/CA-CB | L26 | 50
LISSE CONTREBARDAGE | 0 | +8.030 | +8.195 | C5/CA-CB | L65 | 50
LISSE CONTREBARDAGE | 0 | +8.149 | +8.314 | C5/CA-CB | L65 | 50
LISSE CONTREBARDAGE | 0 | +8.268 | +8.429 | C5/CA-CB | L26 | 50
LISSE CONTREBARDAGE | 0 | +8.022 | +8.195 | C1/CA-CB | L27 | 50
LISSE CONTREBARDAGE | 0 | +8.149 | +8.314 | C1/CA-CB | L65 | 50
LISSE CONTREBARDAGE | 0 | +8.268 | +8.429 | C1/CA-CB | L26 | 50
POTEAU | 0 | -0.200 | +8.550 | C4/CA | PT12 | 334.997
PANNE | 0 | +7.451 | +7.573 | C8'-C9/CB | PN18 | 64
PANNE | 0 | +7.571 | +7.693 | C8'-C9/CA-CB | PN10 | 64
PANNE | 0 | +7.690 | +7.812 | C8'-C9/CA-CB | PN10 | 64
PANNE | 0 | +7.810 | +7.932 | C8'-C9/CA-CB | PN10 | 64
PANNE | 0 | +7.778 | +8.052 | C8-C9/CA | PN1 | 135
PANNE | 0 | +7.371 | +7.574 | C7-C8/CB | PN9 | 100
PANNE | 0 | +7.490 | +7.693 | C7-C8/CA-CB | PN9 | 100
PANNE | 0 | +7.610 | +7.813 | C7-C8/CA-CB | PN9 | 100
PANNE | 0 | +7.729 | +7.932 | C7-C8/CA-CB | PN15 | 100
PANNE | 0 | +7.848 | +8.051 | C7-C8/CA | PN8 | 100
PANNE | 0 | +7.391 | +7.574 | C5-C6/CB | PN16 | 91
PANNE | 0 | +7.510 | +7.693 | C5-C6/CA-CB | PN16 | 91
PANNE | 0 | +7.630 | +7.813 | C5-C6/CA-CB | PN16 | 91
PANNE | 0 | +7.749 | +7.932 | C5-C6/CA-CB | PN17 | 91
PANNE | 0 | +7.861 | +8.044 | C5-C6/CA | PN2 | 91
POTEAU | 0 | -0.200 | +8.445 | C2/CA | PT6 | 310
PANNE | 0 | +7.371 | +7.574 | C3-C4/CB | PN7 | 100
PANNE | 0 | +7.371 | +7.574 | C2-C3/CB | PN5 | 100
PANNE | 0 | +7.490 | +7.693 | C3-C4/CA-CB | PN7 | 100
PANNE | 0 | +7.490 | +7.693 | C2-C3/CA-CB | PN5 | 100
PANNE | 0 | +7.610 | +7.813 | C3-C4/CA-CB | PN14 | 100
PANNE | 0 | +7.610 | +7.813 | C2-C3/CA-CB | PN13 | 100
PANNE | 0 | +7.729 | +7.932 | C3-C4/CA-CB | PN14 | 100
PANNE | 0 | +7.729 | +7.932 | C2-C3/CA-CB | PN13 | 100
PANNE | 0 | +7.848 | +8.051 | C3-C4/CA | PN6 | 100
PANNE | 0 | +7.848 | +8.051 | C2-C3/CA | PN13 | 100
LONGERON | 0 | +7.117 | +7.250 | C8/CA-CB | L32 | 140
LONGERON | 0 | +7.079 | +7.250 | C6/CA-CB | L40 | 180
LONGERON | 0 | +7.060 | +7.250 | C4/CA-CB | L39 | 200
TRAVERSE | 0 | +7.117 | +8.047 | C8'/CA-CB | T2 | 190
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C9/CA | PS2 | 500
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C8/CA | PS2 | 500
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C4/CA | PS2 | 500
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C7/CA | PS2 | 500
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C3/CA | PS1 | 500
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C2/CA | PS1 | 500
PRESCELLEMENT PS24 | 0 | -0.600 | -0.100 | C1/CA | PS1 | 500
2 x ATTACHE | 0 | -0.200 | -0.050 | C1/CA | A1 | 150
2 x ATTACHE | 0 | -0.200 | -0.050 | C1/CB | A1 | 150
6 x ATTACHE | 0 | -0.200 | -0.050 | C1/CA-CB | A1 | 150
POTEAU | 0 | -0.180 | +7.925 | C1/CA-CB | PT9 | 135
POTEAU | 0 | -0.180 | +7.805 | C1/CA-CB | PT8 | 135
POTEAU | 0 | -0.180 | +7.685 | C1/CA-CB | PT7 | 135
PANNE | 0 | +7.729 | +7.932 | C1-C2/CA-CB | PN4 | 100
PANNE | 0 | +7.610 | +7.813 | C1-C2/CA-CB | PN4 | 100
PANNE | 0 | +7.490 | +7.693 | C1-C2/CA-CB | PN4 | 100
PANNE | 0 | +7.371 | +7.574 | C1-C2/CB | PN3 | 100
PANNE | 0 | +7.848 | +8.051 | C1-C2/CA | PN12 | 100
POTEAU | 0 | -0.180 | +7.840 | C1/CA | PT1 | 180

# IfcMechanicalFastener: Bolt assembly (2678)
In: Undefined
Tekla Boulons - Lieu Boulonnage: Montage
Name | NominalDiameter (mm) = Diamètre rondelle (mm) | NominalLength (mm) = Longueur (mm) | Material = Standard | Quantité de rondelle | Quantité d'écrou | Trou oblong Y (mm) | Trou oblong X (mm) | Diamètre du trou (mm) | Quantité | Diamètre (mm)
43 x Bolt assembly | 12 | 50 | 8.8-SB-GALVA | 2 | 2 | 0 | 14 | 14 | 2 | 12
14 x Bolt assembly | 20 | 10 | 6.8 | 0 | 0 | 0 | 0 | 22 | 1 | 22 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M20-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M20-E-6.8; Nom: M20*40
34 x Bolt assembly | 12 | 10 | 6.8 | 0 | 0 | 0 | 0 | 14 | 1 | 14 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M12-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M12-E-6.8; Nom: M12*25
21 x Bolt assembly | 12 | 12 | 6.8 | 0 | 0 | 0 | 0 | 14 | 4 | 14 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M12-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M12-E-6.8; Nom: M12*25
7 x Bolt assembly | 12 | 89.2 | HILTI-HSA-R | 0 | 6 | 0 | 0 | 14 | 6 | 12
14 x Bolt assembly | 30 | 5 | 6.8 | 0 | 0 | 0 | 0 | 32 | 2 | 32 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M30-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M30-E-6.8; Nom: M30*90
57 x Bolt assembly | 12 | 40 | 8.8-SB-GALVA | 0 | 2 | 0 | 0 | 14 | 2 | 12
4 x Bolt assembly | 12 | 50 | 8.8-SB-GALVA | 1 | 1 | 0 | 14 | 14 | 1 | 12
4 x Bolt assembly | 12 | 5 | 6.8 | 0 | 0 | 0 | 0 | 14 | 1 | 14 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M12-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M12-E-6.8; Nom: M12*25
4 x Bolt assembly | 8 | 20 | 6.8 | 0 | 2 | 0 | 0 | 10 | 2 | 8 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M8-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M8-E-6.8; Nom: M8*20
38 x Bolt assembly | 12 | 30 | 8.8-SB-GALVA | 0 | 2 | 0 | 0 | 14 | 2 | 12
14 x Bolt assembly | 12 | 8 | 6.8 | 0 | 0 | 0 | 0 | 14 | 4 | 14 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M12-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M12-E-6.8; Nom: M12*25
20 x Bolt assembly | 12 | 89.2 | HILTI-HSA-R | 0 | 4 | 0 | 0 | 14 | 4 | 12
4 x Bolt assembly | 12 | 30 | 8.8-SB-GALVA | 0 | 6 | 0 | 0 | 14 | 6 | 12
4 x Bolt assembly | 12 | 30 | 8.8-SB-GALVA | 0 | 5 | 0 | 0 | 14 | 5 | 12
8 x Bolt assembly | 12 | 40 | 8.8-SB-GALVA | 0 | 3 | 0 | 0 | 14 | 3 | 12
49 x Bolt assembly | 12 | 30 | 8.8-SB-GALVA | 0 | 1 | 0 | 0 | 14 | 1 | 12
44 x Bolt assembly | 12 | 40 | 8.8-SB-GALVA | 1 | 1 | 0 | 14 | 14 | 1 | 12
6 x Bolt assembly | 6 | 10 | 6.8 | 0 | 0 | 0 | 0 | 8 | 1 | 8 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M6-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M6-E-6.8; Nom: M6*10
10 x Bolt assembly | 12 | 30 | 8.8-SB-GALVA | 0 | 3 | 0 | 0 | 14 | 3 | 12
6 x Bolt assembly | 12 | 40 | 8.8-SB-GALVA | 3 | 3 | 14 | 0 | 14 | 3 | 12
4 x Bolt assembly | 12 | 30 | 8.8-SB-GALVA | 0 | 4 | 0 | 0 | 14 | 4 | 12
200 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 14 | 2 | 12
24 x Bolt assembly | 12 | 3 | 6.8 | 0 | 0 | 0 | 0 | 14 | 1 | 14 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M12-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M12-E-6.8; Nom: M12*25
Bolt assembly | 8 | 30 | 6.8 | 0 | 2 | 0 | 0 | 10 | 2 | 8 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M8-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M8-E-6.8; Nom: M8*30
Bolt assembly | 8 | 30 | 6.8 | 0 | 5 | 0 | 0 | 10 | 5 | 8 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M8-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M8-E-6.8; Nom: M8*30
5 x Bolt assembly | 8 | 30 | 6.8 | 0 | 7 | 0 | 0 | 10 | 7 | 8 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M8-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M8-E-6.8; Nom: M8*30
37 x Bolt assembly | 12 | 8.5 | 8.8-SB-ZINGUE | 0 | 0 | 0 | 0 | 14 | 2 | 14
81 x Bolt assembly | 12 | 50 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 14 | 2 | 12
20 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 3 | 0 | 0 | 14 | 3 | 12
7 x Bolt assembly | 12 | 50 | 8.8-SB-ZINGUE | 0 | 3 | 0 | 0 | 14 | 3 | 12
10 x Bolt assembly | 12 | 60 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 14 | 2 | 12
4 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 2 | 2 | 0 | 11 | 14 | 2 | 12
131 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 14 | 2 | 12
2 x Bolt assembly | 12 | 10.2 | 8.8-SB-ZINGUE | 0 | 0 | 0 | 0 | 14 | 1 | 14
218 x Bolt assembly | 30 | 4 | 6.8 | 0 | 0 | 0 | 0 | 30 | 2 | 30 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M30-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M30-E-6.8; Nom: M30*90
85 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 2 | 2 | 0 | 14 | 14 | 2 | 12
2 x Bolt assembly | 12 | 7.4 | #_SB-8.8-ZINGUE | 0 | 0 | 0 | 14 | 14 | 6 | 14
2 x Bolt assembly | 12 | 7.4 | #_SB-8.8-ZINGUE | 0 | 0 | 0 | 14 | 14 | 11 | 14
2 x Bolt assembly | 10 | 30 | 6.8 | 0 | 8 | 0 | 0 | 12 | 8 | 10 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M10-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M10-E-6.8; Nom: M10*30
4 x Bolt assembly | 12 | 40 | 8.8-SB-GALVA | 0 | 4 | 0 | 0 | 14 | 4 | 12
19 x Bolt assembly | 10 | 30 | 6.8 | 0 | 2 | 0 | 0 | 12 | 2 | 10 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M10-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M10-E-6.8; Nom: M10*30
Bolt assembly | 10 | 30 | 6.8 | 0 | 6 | 0 | 0 | 12 | 6 | 10 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M10-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M10-E-6.8; Nom: M10*30
23 x Bolt assembly | 10 | 30 | 6.8 | 0 | 4 | 0 | 0 | 12 | 4 | 10 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M10-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M10-E-6.8; Nom: M10*30
16 x Bolt assembly | 12 | 40 | 8.8-SB-GALVA | 0 | 1 | 0 | 0 | 14 | 1 | 12
Bolt assembly | 12 | 40 | 6.8-SB-ZINGUE | 0 | 10 | 0 | 0 | 14 | 10 | 12
Bolt assembly | 12 | 40 | 6.8-SB-ZINGUE | 0 | 8 | 0 | 0 | 14 | 8 | 12
72 x Bolt assembly | 16 | 40 | #_SB-8.8-ZINGUE | 0 | 3 | 0 | 0 | 18 | 3 | 16
2 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 2 | 2 | 0 | 21 | 14 | 2 | 12
3 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 2 | 2 | 14 | 0 | 14 | 2 | 12
4 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 4 | 4 | 14 | 0 | 14 | 4 | 12
Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 3 | 3 | 14 | 0 | 14 | 3 | 12
2 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 5 | 0 | 0 | 14 | 5 | 12
8 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 7 | 0 | 0 | 14 | 7 | 12
7 x Bolt assembly | 12 | 89.2 | HILTI-HSA-R | 0 | 2 | 0 | 0 | 14 | 2 | 12
2 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 4 | 0 | 0 | 14 | 4 | 12
110 x Bolt assembly | 16 | 40 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 18 | 2 | 16
53 x Bolt assembly | 16 | 40 | 8.8-SB-ZINGUE | 0 | 4 | 0 | 0 | 18 | 4 | 16
115 x Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 1 | 0 | 0 | 18 | 1 | 16
3 x Bolt assembly | 10 | 30 | 6.8 | 0 | 1 | 0 | 0 | 12 | 1 | 10 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M10-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M10-E-6.8; Nom: M10*30
2 x Bolt assembly | 16 | 6 | 8.8-SB-ZINGUE | 0 | 0 | 0 | 0 | 18 | 1 | 18
36 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 0 | 3 | 0 | 0 | 14 | 3 | 12
174 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 0 | 1 | 0 | 0 | 14 | 1 | 12
35 x Bolt assembly | 16 | 30 | 8.8-SB-ZINGUE | 0 | 3 | 0 | 0 | 18 | 3 | 16
17 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 0 | 6 | 0 | 0 | 14 | 6 | 12
6 x Bolt assembly | 16 | 30 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 18 | 2 | 16
Bolt assembly | 12 | 30 | 6.8 | 0 | 6 | 0 | 0 | 14 | 6 | 12 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M12-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M12-E-6.8; Nom: M12*30
50 x Bolt assembly | 27 | 10 | 6.8 | 0 | 0 | 0 | 0 | 28 | 1 | 28 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M27-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M27-E-6.8; Nom: M27*50
12 x Bolt assembly | 12 | 40 | #_SB-8.8-ZINGUE | 4 | 4 | 0 | 14 | 14 | 4 | 12
3 x Bolt assembly | 12 | 40 | #_SB-8.8-ZINGUE | 1 | 1 | 0 | 14 | 14 | 1 | 12
39 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 2 | 2 | 0 | 14 | 14 | 2 | 12
48 x Bolt assembly | 12 | 50 | 8.8-SB-ZINGUE | 0 | 4 | 0 | 0 | 14 | 4 | 12
20 x Bolt assembly | 30 | 4 | 6.8 | 0 | 0 | 0 | 0 | 30 | 1 | 30 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M30-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M30-E-6.8; Nom: M30*90
12 x Bolt assembly | 16 | 40 | 8.8-SB-ZINGUE | 0 | 1 | 0 | 0 | 18 | 1 | 16
44 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 0 | 4 | 0 | 0 | 14 | 4 | 12
2 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 6 | 0 | 0 | 14 | 6 | 12
Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 12 | 0 | 0 | 18 | 12 | 16
2 x Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 10 | 0 | 0 | 18 | 10 | 16
2 x Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 4 | 4 | 0 | 0 | 18 | 4 | 16
18 x Bolt assembly | 12 | 130 | 6.8 | 0 | 2 | 0 | 0 | 14 | 2 | 12 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M12-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M12-E-6.8; Nom: M12*130
18 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 2 | 2 | 0 | 0 | 14 | 2 | 12
6 x Bolt assembly | 12 | 30 | 8.8-SB-ZINGUE | 0 | 10 | 0 | 0 | 14 | 10 | 12
15 x Bolt assembly | 6 | 16 | 6.8 | 0 | 2 | 0 | 0 | 8 | 2 | 6 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M6-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M6-E-6.8; Nom: M6*16
Bolt assembly | 12 | 140 | 8.8-SB-ZINGUE | 4 | 2 | 0 | 14 | 14 | 2 | 12
25 x Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 18 | 2 | 16
32 x Bolt assembly | 16 | 30 | #_SB-8.8-ZINGUE | 0 | 2 | 0 | 0 | 18 | 2 | 16
26 x Bolt assembly | 16 | 40 | #_SB-8.8-ZINGUE | 0 | 2 | 0 | 0 | 18 | 2 | 16
11 x Bolt assembly | 16 | 40 | 8.8-SB-ZINGUE | 0 | 6 | 0 | 0 | 18 | 6 | 16
12 x Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 4 | 0 | 0 | 18 | 4 | 16
5 x Bolt assembly | 16 | 40 | 8.8-SB-ZINGUE | 0 | 8 | 0 | 0 | 18 | 8 | 16
2 x Bolt assembly | 16 | 40 | 8.8-SB-ZINGUE | 0 | 3 | 0 | 0 | 18 | 3 | 16
Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 6 | 0 | 0 | 18 | 6 | 16
3 x Bolt assembly | 12 | 40 | #_SB-8.8-ZINGUE | 0 | 2 | 0 | 0 | 14 | 2 | 12
6 x Bolt assembly | 12 | 40 | #_SB-8.8-ZINGUE | 0 | 1 | 0 | 0 | 14 | 1 | 12
2 x Bolt assembly | 12 | 50 | 8.8-SB-ZINGUE | 0 | 6 | 0 | 0 | 14 | 6 | 12
80 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 1 | 0 | 0 | 14 | 1 | 12
8 x Bolt assembly | 12 | 50 | 8.8-SB-ZINGUE | 0 | 1 | 0 | 0 | 14 | 1 | 12
36 x Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 3 | 0 | 0 | 18 | 3 | 16
2 x Bolt assembly | 12 | 50 | 8.8-SB-ZINGUE | 0 | 3 | 0 | 0 | 12 | 3 | 12
20 x Bolt assembly | 12 | 40 | 8.8-SB-ZINGUE | 0 | 6 | 0 | 0 | 12 | 6 | 12
8 x Bolt assembly | 12 | 50 | 8.8-SB-ZINGUE | 0 | 6 | 0 | 0 | 12 | 6 | 12
Bolt assembly | 12 | 30 | 8.8 | 0 | 3 | 0 | 0 | 14 | 3 | 12 | Tekla Boulons - Type rondelle: PLA-8.8; Nom rondelle: RONDELLE-M12-PLA-8.8; Type écrou: E-8.8; Nom écrou: ECROU-M12-E-8.8; Nom: M12*30
4 x Bolt assembly | 16 | 146.2 | HILTI-HST-R | 0 | 1 | 0 | 0 | 18 | 1 | 16
2 x Bolt assembly | 16 | 50 | 8.8-SB-ZINGUE | 0 | 16 | 0 | 0 | 18 | 16 | 16
3 x Bolt assembly | 20 | 60 | HR10.9 | 4 | 2 | 0 | 22 | 22 | 2 | 20 | Tekla Boulons - Type rondelle: PLA-HR10.9; Nom rondelle: RONDELLE-M20-PLA-HR10.9; Type écrou: E-HR10.9; Nom écrou: ECROU-M20-E-HR10.9; Nom: M20*60
13 x Bolt assembly | 20 | 5.5 | 6.8 | 0 | 0 | 0 | 0 | 22 | 1 | 22 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M20-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M20-E-6.8; Nom: M20*40
22 x Bolt assembly | 30 | 15 | 6.8 | 0 | 0 | 0 | 0 | 50 | 1 | 50 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M30-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M30-E-6.8; Nom: M30*90
15 x Bolt assembly | 16 | 146.2 | HILTI-HST-R | 0 | 2 | 0 | 0 | 18 | 2 | 16
3 x Bolt assembly | 16 | 60 | HR10.9 | 4 | 2 | 0 | 18 | 18 | 2 | 16 | Tekla Boulons - Type rondelle: PLA-HR10.9; Nom rondelle: RONDELLE-M16-PLA-HR10.9; Type écrou: E-HR10.9; Nom écrou: ECROU-M16-E-HR10.9; Nom: M16*60
5 x Bolt assembly | 16 | 60 | HR10.9 | 6 | 3 | 0 | 18 | 18 | 3 | 16 | Tekla Boulons - Type rondelle: PLA-HR10.9; Nom rondelle: RONDELLE-M16-PLA-HR10.9; Type écrou: E-HR10.9; Nom écrou: ECROU-M16-E-HR10.9; Nom: M16*60
3 x Bolt assembly | 16 | 50 | HR10.9 | 8 | 4 | 0 | 18 | 18 | 4 | 16 | Tekla Boulons - Type rondelle: PLA-HR10.9; Nom rondelle: RONDELLE-M16-PLA-HR10.9; Type écrou: E-HR10.9; Nom écrou: ECROU-M16-E-HR10.9; Nom: M16*50
Bolt assembly | 16 | 50 | HR10.9 | 4 | 2 | 0 | 18 | 18 | 2 | 16 | Tekla Boulons - Type rondelle: PLA-HR10.9; Nom rondelle: RONDELLE-M16-PLA-HR10.9; Type écrou: E-HR10.9; Nom écrou: ECROU-M16-E-HR10.9; Nom: M16*50
2 x Bolt assembly | 16 | 50 | HR10.9 | 4 | 2 | 0 | 0 | 18 | 2 | 16 | Tekla Boulons - Type rondelle: PLA-HR10.9; Nom rondelle: RONDELLE-M16-PLA-HR10.9; Type écrou: E-HR10.9; Nom écrou: ECROU-M16-E-HR10.9; Nom: M16*50
Bolt assembly | 16 | 70 | HR10.9 | 4 | 2 | 0 | 18 | 18 | 2 | 16 | Tekla Boulons - Type rondelle: PLA-HR10.9; Nom rondelle: RONDELLE-M16-PLA-HR10.9; Type écrou: E-HR10.9; Nom écrou: ECROU-M16-E-HR10.9; Nom: M16*70
Bolt assembly | 20 | 5 | 6.8 | 0 | 0 | 0 | 0 | 22 | 1 | 22 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M20-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M20-E-6.8; Nom: M20*40
22 x Bolt assembly | 24 | 15 | 6.8 | 0 | 0 | 0 | 0 | 26 | 1 | 26 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M24-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M24-E-6.8; Nom: M24*50
22 x Bolt assembly | 22 | 15 | 6.8 | 0 | 0 | 0 | 0 | 24 | 1 | 24 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M22-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M22-E-6.8; Nom: M22*40
11 x Bolt assembly | 8 | 10 | 6.8 | 0 | 0 | 0 | 0 | 10 | 1 | 10 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M8-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M8-E-6.8; Nom: M8*12
11 x Bolt assembly | 24 | 10 | 6.8 | 0 | 0 | 0 | 0 | 26 | 2 | 26 | Tekla Boulons - Type rondelle: PLA-6.8; Nom rondelle: RONDELLE-M24-PLA-6.8; Type écrou: E-6.8; Nom écrou: ECROU-M24-E-6.8; Nom: M24*50
5 x Bolt assembly | 16 | 60 | 8.8-SB-ZINGUE | 0 | 2 | 0 | 0 | 18 | 2 | 16

# IfcMember: IPE200 (10)
In: Undefined
Description: IPE200; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE200; Nom: TRAVERSE SHED
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00285 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
TRAVERSE SHED | +8.425 | +10.553 | 109 | TS10 | 3.5 | 4539.2 | 4539.23 | 3.48613 | 0.0120649 | 0.0129368
TRAVERSE SHED | +8.425 | +10.553 | 109 | TS9 | 3.5 | 4539.2 | 4539.23 | 3.48613 | 0.0120649 | 0.0129368
TRAVERSE SHED | +8.425 | +10.553 | 66 | TS8 | 3.5 | 4539.2 | 4539.23 | 3.48613 | 0.0120649 | 0.0129368
TRAVERSE SHED | +8.425 | +10.553 | 37 | TS7 | 3.5 | 4539.2 | 4539.23 | 3.48613 | 0.0120649 | 0.0129368
TRAVERSE SHED | +8.425 | +10.553 | 66 | TS6 | 3.5 | 4539.2 | 4539.23 | 3.48613 | 0.0120649 | 0.0129368
TRAVERSE SHED | +8.560 | +11.366 | 65 | TS5 | 4.7 | 6098 | 6097.96 | 4.68324 | 0.0159487 | 0.0173792
TRAVERSE SHED | +8.428 | +11.366 | 31 | TS4 | 4.7 | 6119.7 | 6119.7 | 4.69993 | 0.0163681 | 0.0174411
TRAVERSE SHED | +8.428 | +11.366 | 60 | TS3 | 4.7 | 6119.7 | 6119.7 | 4.69993 | 0.0163681 | 0.0174411
TRAVERSE SHED | +8.428 | +11.366 | 25 | TS2 | 4.7 | 6119.7 | 6119.7 | 4.69993 | 0.0163681 | 0.0174411
TRAVERSE SHED | +8.428 | +11.366 | 60 | TS1 | 4.7 | 6119.7 | 6119.7 | 4.69993 | 0.0163681 | 0.0174411

# IfcMember: IPE240 (5)
In: Undefined
Description: IPE240; Material: Undefined/S275-E28
Tekla Commun - Niveau haut: +12.167; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE240; Nom: TRAVERSE SHED
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 240 mm; Largeur: 120 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.003909 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
TRAVERSE SHED | +8.560 | 77 | TS15 | 7.1 | 7780.8 | 7780.75 | 7.17385 | 0.0278462 | 0.030415
TRAVERSE SHED | +8.405 | 242 | TS14 | 7.3 | 7802.3 | 7802.33 | 7.19374 | 0.0285092 | 0.0304993
TRAVERSE SHED | +8.405 | 243 | TS13 | 7.3 | 7802.3 | 7802.33 | 7.19374 | 0.0285092 | 0.0304993
TRAVERSE SHED | +8.405 | 242 | TS12 | 7.3 | 7802.3 | 7802.33 | 7.19374 | 0.0285092 | 0.0304993
TRAVERSE SHED | +8.405 | 72 | TS11 | 7.3 | 7802.3 | 7802.33 | 7.19374 | 0.0285092 | 0.0304993

# IfcMember: L120*80*10 (40)
In: Undefined
Description: L120*80*10; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L120*80*10; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 120 mm; Largeur: 80 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00191 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
ATTACHE | +7.807 | +8.010 | A43 | 200 | 0.0782 | 0.00038 | 0.000382
ATTACHE | +7.810 | +8.013 | A42 | 200 | 0.0782 | 0.00038 | 0.000382
ATTACHE | +7.887 | +8.010 | A41 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.890 | +8.013 | A41 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.887 | +8.010 | A40 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.890 | +8.013 | A40 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.768 | +7.890 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.771 | +7.893 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.649 | +7.771 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.651 | +7.774 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.410 | +7.532 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.412 | +7.535 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.529 | +7.652 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
2 x ATTACHE | +7.532 | +7.654 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.890 | +8.012 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.892 | +8.015 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.778 | +7.900 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.781 | +7.903 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.420 | +7.542 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.422 | +7.545 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.539 | +7.662 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.542 | +7.664 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.659 | +7.781 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.661 | +7.784 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.887 | +8.010 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.890 | +8.013 | A38 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.768 | +7.890 | A39 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.771 | +7.893 | A39 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.649 | +7.771 | A39 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.651 | +7.774 | A39 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.529 | +7.652 | A39 | 120 | 0.04692 | 0.000228 | 0.0002292
ATTACHE | +7.532 | +7.654 | A39 | 120 | 0.04692 | 0.000228 | 0.0002292

# IfcMember: L200*100*10 (78)
In: Undefined
Description: L200*100*10; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L200*100*10; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00292 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Largeur (mm) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
4 x ATTACHE | +7.410 | +7.532 | A54 | 0.1 | 70 | 120 | 0.07044 | 0.000312 | 0.0003504
4 x ATTACHE | +7.412 | +7.535 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
2 x ATTACHE | +7.804 | +8.010 | A58 | 0.1 | 100 | 200 | 0.1174 | 0.00058 | 0.000584
ATTACHE | +7.807 | +8.010 | A59 | 0.1 | 100 | 200 | 0.1174 | 0.00058 | 0.000584
ATTACHE | +7.810 | +8.013 | A59 | 0.1 | 100 | 200 | 0.1174 | 0.00058 | 0.000584
ATTACHE | +7.470 | +7.532 | A61 | 0 | 70 | 60 | 0.03522 | 0.000156 | 0.0001752
2 x ATTACHE | +7.472 | +7.536 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
2 x ATTACHE | +7.588 | +7.652 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
2 x ATTACHE | +7.592 | +7.655 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
2 x ATTACHE | +7.708 | +7.771 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
2 x ATTACHE | +7.711 | +7.774 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
2 x ATTACHE | +7.827 | +7.890 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
2 x ATTACHE | +7.831 | +7.894 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
ATTACHE | +7.469 | +7.532 | A60 | 0 | 100 | 60 | 0.03522 | 0.000174 | 0.0001752
ATTACHE | +7.767 | +7.890 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.771 | +7.894 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.409 | +7.532 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.412 | +7.535 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.528 | +7.652 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.532 | +7.655 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.648 | +7.771 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.651 | +7.774 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.889 | +8.012 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.892 | +8.016 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.419 | +7.542 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.422 | +7.545 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.538 | +7.662 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.542 | +7.665 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.658 | +7.781 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.661 | +7.784 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.777 | +7.900 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
ATTACHE | +7.781 | +7.904 | A55 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.887 | +8.010 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.890 | +8.013 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.528 | +7.652 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.532 | +7.655 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.648 | +7.771 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.651 | +7.774 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.767 | +7.890 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504
4 x ATTACHE | +7.771 | +7.894 | A53 | 0.1 | 100 | 120 | 0.07044 | 0.000348 | 0.0003504

# IfcMember: L40*4 (8)
In: Undefined
Description: L40*4; Material: Undefined/S235-E24
Tekla Commun - Classe: 2; Matériau: S235-E24; Profil: L40*4
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 40 mm; Largeur: 40 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000308 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x STABILITE | +7.175 | +7.552 | S29 | 1 | STABILITE | 0.1 | 688.9 | 688.884 | 0.106777 | 0.000209421 | 0.000212176
2 x STABILITE | +7.188 | +7.670 | S28 | 1 | STABILITE | 0.1 | 757.5 | 757.453 | 0.117405 | 0.000230266 | 0.000233296
2 x STABILITE | +7.202 | +7.790 | S27 | 1 | STABILITE | 0.1 | 835.6 | 835.634 | 0.129523 | 0.000254033 | 0.000257375
2 x STABILTE | -0.108 | +2.580 | S14 | 2 | STABILTE | 0.7 | 3982 | 3982 | 0.61721 | 0.00121136 | 0.00122646 | Tekla Commun - Finition: GALVA

# IfcMember: L60*6 (36)
In: Undefined
Description: L60*6; Material: Undefined/S235-E24
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 60 mm
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L60*6; Nom: ATTACHE
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.000691 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Longueur (mm) = Length (mm) | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x ATTACHE | 180 | +8.493 | +8.630 | A28 | 0.04194 | 0.00012312 | 0.00012438
4 x ATTACHE | 150 | +9.391 | +9.511 | A27 | 0.03495 | 0.0001026 | 0.00010365
4 x ATTACHE | 150 | +8.499 | +8.619 | A27 | 0.03495 | 0.0001026 | 0.00010365
4 x ATTACHE | 150 | +10.283 | +10.403 | A27 | 0.03495 | 0.0001026 | 0.00010365
3 x ATTACHE | 180 | +8.504 | +8.640 | A28 | 0.04194 | 0.00012312 | 0.00012438
ATTACHE | 180 | +8.578 | +8.714 | A28 | 0.04194 | 0.00012312 | 0.00012438
4 x ATTACHE | 180 | +11.078 | +11.214 | A28 | 0.04194 | 0.00012312 | 0.00012438
4 x ATTACHE | 180 | +9.791 | +9.927 | A28 | 0.04194 | 0.00012312 | 0.00012438
ATTACHE | 180 | +8.572 | +8.708 | A28 | 0.04194 | 0.00012312 | 0.00012438
4 x ATTACHE | 180 | +10.174 | +10.311 | A28 | 0.04194 | 0.00012312 | 0.00012438
4 x ATTACHE | 180 | +11.855 | +11.992 | A28 | 0.04194 | 0.00012312 | 0.00012438

# IfcMember: L70*7 (3)
In: Undefined
Description: L70*7; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L70*7; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 70 mm; Largeur: 70 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00094 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
FEUILLURE | +8.570 | +11.037 | F20 | 1.5 | 5450 | 1.4824 | 0.00507395 | 0.005123
FEUILLURE | +8.570 | +11.860 | F19 | 1.9 | 7015 | 1.90808 | 0.00653097 | 0.0065941
FEUILLURE | +8.567 | +12.662 | F16 | 2.5 | 8700 | 2.3664 | 0.0080997 | 0.008178

# IfcMember: PL10*100 (9)
In: Undefined
Description: PL10*100; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 271; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*100; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 10 mm; Longueur: 210 mm
Pset_MemberCommon - LoadBearing: yes; Reference: 271
BaseQuantities - Length: 210 mm; OuterSurfaceArea: 0.0482 m2; GrossSurfaceArea: 0.0482 m2; CrossSectionArea: 0.001 m2; NetVolume: 0.00021 m3; GrossVolume: 0.00021 m3; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage
3 x PLATINE | +9.660 | +9.761 | S22
3 x PLATINE | +10.435 | +10.541 | S21
3 x PLATINE | +11.184 | +11.290 | S20

# IfcMember: PL10*60 (8)
In: Undefined
Description: PL10*60; Material: Undefined/S235-E24
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 10 mm; Longueur: 130 mm
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 4; Matériau: S235-E24; Profil: PL10*60; Nom: PLATINE
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - Length: 130 mm; OuterSurfaceArea: 0.0194 m2; GrossSurfaceArea: 0.0194 m2; CrossSectionArea: 0.0006 m2; NetVolume: 0.000078 m3; GrossVolume: 0.000078 m3; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage
PLATINE | +7.560 | +7.651 | 525 | GC12
PLATINE | +7.560 | +7.651 | 525 | GC8
3 x PLATINE | +8.187 | +8.269 | 525 | GC3
2 x PLATINE | +8.187 | +8.269 | 525 | GC2
PLATINE | +8.187 | +8.269 | 318 | GC1

# IfcMember: PL15*103.5 (8)
In: Undefined
Description: PL15*103.5; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.185; Niveau haut: +0.009; Repère de pièce: 27; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL15*103.5; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 103.5 mm; Largeur: 15 mm; Longueur: 226.7 mm
Pset_MemberCommon - LoadBearing: yes; Reference: 27
BaseQuantities - CrossSectionArea: 0.0015525 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Repère d'assemblage | Length (mm) | OuterSurfaceArea (m2) | GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
2 x PLATINE | PT10 | 226.683 | 0.0562532 | 0.0568289 | 0.000348926 | 0.000351926
2 x PLATINE | PT10 | 226.686 | 0.0562539 | 0.0568297 | 0.000348931 | 0.000351931
2 x PLATINE | PT12 | 226.683 | 0.0562532 | 0.0568289 | 0.000348926 | 0.000351926
2 x PLATINE | PT12 | 226.686 | 0.0562539 | 0.0568297 | 0.000348931 | 0.000351931

# IfcMember: PL200*6 (2)
In: Undefined
Description: PL200*6; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.531; Niveau haut: +8.111; Repère de pièce: GC0(?); Repère d'assemblage: GC0(?); Finition: GALVA; Phase: 3; Classe: 4; Matériau: S235-E24; Profil: PL200*6; Nom: CACHE VIDE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 200 mm; Largeur: 6 mm; Longueur: 900 mm
Pset_MemberCommon - LoadBearing: yes; Reference: GC0(?)
BaseQuantities - Length: 900 mm; OuterSurfaceArea: 0.3732 m2; GrossSurfaceArea: 0.3732 m2; CrossSectionArea: 0.0012 m2; NetVolume: 0.00108 m3; GrossVolume: 0.00108 m3; NetWeight: 0 kg; GrossWeight: 0 kg

# IfcMember: TUBE-21.3*2 (12)
In: Undefined
Description: TUBE-21.3*2; Material: Undefined/S235-E24
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 4; Matériau: S235-E24; Profil: TUBE-21.3*2; Nom: LISSE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 21.3 mm; Largeur: 21.3 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0001158 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) = GrossVolume (m3)
2 x LISSE | +8.643 | +9.159 | 625(?) | GC0(?) | 788.6 | 788.637 | 0.051493 | 0.0000898729
LISSE | +8.643 | +9.258 | 625 | GC12 | 943.8 | 943.779 | 0.0617562 | 0.000107838
LISSE | +8.016 | +8.664 | 624 | GC12 | 987.3 | 987.296 | 0.0646227 | 0.000112855
LISSE | +8.643 | +9.258 | 625 | GC8 | 943.8 | 943.779 | 0.0617562 | 0.000107838
LISSE | +8.016 | +8.664 | 624 | GC8 | 987.3 | 987.296 | 0.0646227 | 0.000112855
2 x LISSE | +8.642 | +9.450 | 620 | GC2 | 1389.1 | 1389.13 | 0.0910763 | 0.000159153
3 x LISSE | +8.642 | +9.450 | 620 | GC3 | 1389.1 | 1389.13 | 0.0910763 | 0.000159153
LISSE | +8.642 | +9.450 | 620 | GC1 | 1389.1 | 1389.13 | 0.0910763 | 0.000159153

# IfcMember: TUBE-60.3*3.2 (2)
In: Undefined
Description: TUBE-60.3*3.2; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +3.159; Niveau haut: +4.174; Repère de pièce: 196; Repère d'assemblage: B14; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: TUBE-60.3*3.2; Nom: BUTON
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 60.3 mm; Largeur: 60.3 mm; Longueur: 2230 mm
Pset_MemberCommon - LoadBearing: yes; Reference: 196
BaseQuantities - Length: 2230 mm; OuterSurfaceArea: 0.417322 m2; GrossSurfaceArea: 0.624478 m2; CrossSectionArea: 0.000559391 m2; NetVolume: 0.00123369 m3; GrossVolume: 0.00185417 m3; NetWeight: 0 kg; GrossWeight: 0 kg

# IfcMember: UPN260 (14)
In: Undefined
Description: UPN260; Material: Undefined/S275-E28
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 2; Matériau: S275-E28; Profil: UPN260; Nom: LIMON
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 260 mm; Largeur: 90 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.00483 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
3 x LIMON | +8.057 | +8.910 | 608 | L90 | 1 | 1346.7 | 1346.65 | 1.12041 | 0.0057237 | 0.00650432
3 x LIMON | +8.057 | +8.910 | 607 | L89 | 1 | 1346.7 | 1346.65 | 1.12041 | 0.0057237 | 0.00650432
LIMON | +7.850 | +8.700 | 536 | L33(?) | 0.7 | 1023.8 | 1023.8 | 0.851798 | 0.00444587 | 0.00494493
LIMON | +7.850 | +8.700 | 535 | L63 | 0.7 | 1023.8 | 1023.8 | 0.851799 | 0.00444587 | 0.00494494
LIMON | +7.378 | +8.110 | 547(?) | L33(?) | 0.7 | 1007.9 | 1007.91 | 0.838578 | 0.00412697 | 0.00486819
LIMON | +7.378 | +8.110 | 546 | L63 | 0.7 | 1007.9 | 1007.91 | 0.838578 | 0.00412697 | 0.00486819
LIMON | +7.850 | +8.700 | 536 | L5(?) | 0.7 | 1023.8 | 1023.8 | 0.851798 | 0.00444587 | 0.00494493
LIMON | +7.850 | +8.700 | 535 | L75(?) | 0.7 | 1023.8 | 1023.8 | 0.851799 | 0.00444587 | 0.00494494
LIMON | +7.378 | +8.110 | 547(?) | L5(?) | 0.7 | 1007.9 | 1007.91 | 0.838578 | 0.00412697 | 0.00486819
LIMON | +7.378 | +8.110 | 546 | L75(?) | 0.7 | 1007.9 | 1007.91 | 0.838578 | 0.00412697 | 0.00486819

# IfcMember: UPN80 (36)
In: Undefined
Description: UPN80; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Classe: 2; Matériau: S275-E28; Profil: UPN80; Nom: DIAGONALE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 80 mm; Largeur: 45 mm
Pset_MemberCommon - LoadBearing: yes
BaseQuantities - CrossSectionArea: 0.0011 m2; NetWeight: 0 kg; GrossWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) = GrossSurfaceArea (m2) | NetVolume (m3) | GrossVolume (m3)
6 x DIAGONALE | +7.296 | +10.377 | D1 | 1.5 | 4703.5 | 4703.55 | 1.47221 | 0.00511226 | 0.0051739
2 x DIAGONALE | +7.296 | +10.377 | D1 | 1.5 | 4703.5 | 4703.54 | 1.47221 | 0.00511226 | 0.0051739
8 x DIAGONALE | +7.309 | +11.177 | D2 | 1.7 | 5260.1 | 5260.1 | 1.64641 | 0.00571628 | 0.00578611
8 x DIAGONALE | +7.319 | +11.968 | D3 | 1.9 | 5863.9 | 5863.9 | 1.8354 | 0.00637266 | 0.00645029
2 x DIAGONALE | +5.247 | +8.303 | D7 | 1.5 | 4211.2 | 4211.19 | 1.3181 | 0.00457791 | 0.00463231
2 x DIAGONALE | +5.242 | +8.308 | D6 | 1.5 | 4426.2 | 4426.2 | 1.3854 | 0.00481235 | 0.00486882
2 x DIAGONALE | +5.271 | +8.279 | D8 | 1.1 | 3481 | 3480.99 | 1.08955 | 0.00378437 | 0.00382909
2 x DIAGONALE | +5.271 | +8.279 | D5 | 1.1 | 3480 | 3480 | 1.08924 | 0.00378437 | 0.00382799
2 x DIAGONALE | +5.255 | +8.295 | D9 | 1.2 | 3919.2 | 3919.24 | 1.22672 | 0.00426216 | 0.00431117
2 x DIAGONALE | +5.261 | +8.289 | D4 | 1.2 | 3731.1 | 3731.05 | 1.16782 | 0.00405792 | 0.00410416

# IfcPlate: TOLE10*100 (3)
In: Undefined
Description: TOLE10*100; Material: Undefined/S235-E24
Tekla Commun - Repère d'assemblage: PT10; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE10*100; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 10 mm
Pset_PlateCommon - LoadBearing: yes
BaseQuantities - Width: 100 mm; CrossSectionArea: 0.0001 m2
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Surface supérieure totale (m2) | Longueur (mm) | NetArea (m2) | GrossArea (m2) | NetVolume (m3) = GrossVolume (m3)
RAIDISSEUR | +7.504 | +8.044 | 360 | 0 | 540 | 0.119766 | 0.054 | 0.000536
RAIDISSEUR | +7.494 | +7.504 | 359 | 0.1 | 560 | 0.123049 | 0.056 | 0.000551
RAIDISSEUR | +8.044 | +8.054 | 359 | 0.1 | 560 | 0.123049 | 0.056 | 0.000551
