Properties of the parts of a building model (IFC2X3), part 2 of 5

# IfcBeam: PL10*500, PLATINE
Tekla Commun - Niveau bas: +8.550; Niveau haut: +8.560; Repère de pièce: 285; Repère d'assemblage: TS15; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*500; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface nette: 0.2 m2; Hauteur: 500 mm; Largeur: 10 mm; Longueur: 150 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 285
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.163 m2; NetVolume: 0.00075 m3; NetWeight: 0 kg

# IfcBeam: PL10*60 (112)
In: Undefined
Description: PL10*60; Material: Undefined/S235-E24
Tekla Commun - Matériau: S235-E24; Profil: PL10*60
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 60 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Finition | Phase | Classe | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
5 x PLATINE | +8.700 | +8.710 | 525(?) | GC0(?) | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
MONTANT | +8.710 | +9.678 | 519(?) | GC0(?) | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
MONTANT | +8.710 | +9.678 | 0(?) | 0(?) | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.000568559
2 x MONTANT | +8.710 | +9.586 | 519(?) | GC0(?) | GALVA | 3 | 4 | MONTANT | 0.1 | 876.5 | 876.489 | 0.120647 | 0.000511416
2 x PLATINE | +8.110 | +8.120 | 525(?) | GC0(?) | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
MONTANT | +8.120 | +9.088 | 519(?) | GC0(?) | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
PLATINE | +8.700 | +8.710 | 0(?) | 0(?) | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
2 x PLATINE | +8.110 | +8.120 | 525 | GC12 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
2 x PLATINE | +8.700 | +8.710 | 525 | GC12 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
PLATINE | +8.700 | +8.710 | 324 | GC8 | GALVA | 3 | 4 | PLATINE | 0 | 65 | 65 | 0.0103 | 0.000039
2 x PLATINE | +8.700 | +8.710 | 324 | GC10 | GALVA | 3 | 4 | PLATINE | 0 | 65 | 65 | 0.0103 | 0.000039
2 x PLATINE | +8.110 | +8.120 | 525 | GC8 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
3 x PLATINE | +8.700 | +8.710 | 525 | GC8 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
2 x MONTANT | +8.710 | +9.678 | 519 | GC8 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
4 x PLATINE | +8.700 | +8.710 | 525 | GC4 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
3 x MONTANT | +8.710 | +9.678 | 519 | GC4 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
MONTANT | +8.710 | +9.678 | 518 | GC8 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
3 x PLATINE | +8.700 | +8.710 | 525 | GC10 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
PLATINE | +8.700 | +8.710 | 324 | GC4 | GALVA | 3 | 4 | PLATINE | 0 | 65 | 65 | 0.0103 | 0.000039
4 x PLATINE | +8.910 | +8.920 | 525 | GC2 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
3 x MONTANT | +8.920 | +9.858 | 509 | GC2 | GALVA | 3 | 4 | MONTANT | 0.1 | 937.6 | 937.6 | 0.129729 | 0.00055056
2 x PLATINE | +8.700 | +8.710 | 319 | GC6 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
2 x MONTANT | +8.710 | +9.678 | 518 | GC6 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
6 x PLATINE | +8.910 | +8.920 | 525 | GC3 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
5 x MONTANT | +8.920 | +9.858 | 509 | GC3 | GALVA | 3 | 4 | MONTANT | 0.1 | 937.6 | 937.6 | 0.129729 | 0.00055056
3 x MONTANT | +8.226 | +9.089 | 514 | GC3 | GALVA | 3 | 4 | MONTANT | 0.1 | 863.2 | 863.191 | 0.118507 | 0.000501747
2 x MONTANT | +8.226 | +9.089 | 507 | GC2 | GALVA | 3 | 4 | MONTANT | 0.1 | 863.2 | 863.191 | 0.118507 | 0.000501747
2 x PLATINE | +8.910 | +8.920 | 318 | GC1 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
2 x MONTANT | +8.920 | +9.858 | 509 | GC1 | GALVA | 3 | 4 | MONTANT | 0.1 | 937.6 | 937.6 | 0.129729 | 0.00055056
MONTANT | +8.226 | +9.089 | 507 | GC1 | GALVA | 3 | 4 | MONTANT | 0.1 | 863.2 | 863.191 | 0.118507 | 0.000501747
MONTANT | +8.710 | +9.678 | 518 | GC4 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
2 x PLATINE | +8.700 | +8.710 | 526 | GC7 | GALVA | 3 | 4 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
2 x MONTANT | +8.710 | +9.678 | 518 | GC7 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
3 x MONTANT | +8.710 | +9.678 | 519 | GC10 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
2 x MONTANT | +8.120 | +9.088 | 519 | GC8 | GALVA | 3 | 4 | MONTANT | 0.1 | 967.6 | 967.6 | 0.133929 | 0.00056856
MONTANT | +7.602 | +8.462 | 517 | GC8 | GALVA | 3 | 4 | MONTANT | 0.1 | 860.1 | 860.124 | 0.117945 | 0.000499055
12 x PLATINE | +8.240 | +8.250 | 282 | MC3 |  | 1 | 5 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
2 x PLATINE | +8.550 | +8.560 | 282 | MC2 |  | 1 | 5 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
12 x PLATINE | +8.240 | +8.250 | 282 | MC1 |  | 1 | 5 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078
4 x PLATINE | +8.240 | +8.250 | 282 | MC2 |  | 1 | 5 | PLATINE | 0 | 130 | 130 | 0.0194 | 0.000078

# IfcBeam: PL10*70 (9)
In: Undefined
Description: PL10*70; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.240; Niveau haut: +8.250; Repère de pièce: 270; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*70; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 70 mm; Largeur: 10 mm; Longueur: 360 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 270
BaseQuantities - Length: 360 mm; OuterSurfaceArea: 0.059 m2; NetVolume: 0.000252 m3; NetWeight: 0 kg
Name | Repère d'assemblage
3 x PLATINE | S20
3 x PLATINE | S22
3 x PLATINE | S21

# IfcBeam: PL10*80 (8)
In: Undefined
Description: PL10*80; Material: Undefined/S235-E24
Tekla Commun - Matériau: S235-E24; Profil: PL10*80
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 80 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
SUPPORT | +5.000 | +5.080 | S42 | S42 | 1 | 3 | SUPPORT | 0.1 | 1.2 | 6735 | 1.2139 | 0.005388
SUPPORT | +5.000 | +5.080 | S16 | S16 | 1 | 3 | SUPPORT | 0.1 | 1.5 | 8195 | 1.4767 | 0.006556
2 x GOUSSET | +3.103 | +3.273 | 498 | B14 | 2 | 2 | GOUSSET | 0 | 0 | 260 | 0.0466612 | 0.00020103 | Tekla Commun - Finition: GALVA
2 x GOUSSET | +4.060 | +4.231 | 498 | B14 | 2 | 2 | GOUSSET | 0 | 0 | 260 | 0.0466612 | 0.00020103 | Tekla Commun - Finition: GALVA
2 x ATTACHE | +8.290 | +8.450 | A5 | A5 | 1 | 2 | ATTACHE | 0 | 0.1 | 270 | 0.052 | 0.000224

# IfcBeam: PL10*82 (4)
In: Undefined
Description: PL10*82
Tekla Commun - Finition: GALVA; Phase: 2; Classe: 2; Profil: PL10*82
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 82 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Matériau | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PLAT | Undefined/S235-E24 | +2.664 | +2.682 | 502 | PT11 | S235-E24 | PLAT | 0 | 150 | 149.999 | 0.0297919 | 0.000125459
PLAT | Undefined/S235-E24 | +2.664 | +2.682 | 502 | PT13 | S235-E24 | PLAT | 0 | 150 | 149.999 | 0.0297919 | 0.000125459
2 x PLATINE | Undefined/S275-E28 | +2.896 | +2.922 | 501 | G11 | S275-E28 | PLATINE | 0.1 | 300 | 300 | 0.05684 | 0.000246

# IfcBeam: PL10*90 (2)
In: Undefined
Description: PL10*90; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.139; Niveau haut: +7.229; Repère de pièce: E1; Repère d'assemblage: E1; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*90; Nom: ECLISSE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 90 mm; Largeur: 10 mm; Longueur: 410 mm
Pset_BeamCommon - LoadBearing: yes; Reference: E1
BaseQuantities - Length: 410 mm; OuterSurfaceArea: 0.0838 m2; NetVolume: 0.000369 m3; NetWeight: 0 kg

# IfcBeam: PL100*5 (15)
In: Undefined
Description: PL100*5; Material: Undefined/S235-E24
Pset_BeamCommon - LoadBearing: yes
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 4; Matériau: S235-E24; Profil: PL100*5; Nom: PLINTHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 100 mm; Largeur: 5 mm
BaseQuantities - NetWeight: 0 kg
Name | Reference = Repère de pièce | Niveau bas | Niveau haut | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PLINTHE | 0(?) | +8.710 | +8.810 | 0(?) | 0.7 | 3850 | 3849.99 | 0.809498 | 0.00192499
PLINTHE | 537 | +8.120 | +8.220 | GC12 | 0.4 | 1735 | 1734.99 | 0.365349 | 0.000867497
PLINTHE | 540 | +8.710 | +8.810 | GC12 | 0.2 | 1100 | 1100 | 0.232 | 0.00055
PLINTHE | 539 | +8.710 | +8.810 | GC10 | 1.1 | 5200 | 5200 | 1.093 | 0.0026
PLINTHE | 538 | +8.710 | +8.810 | GC4 | 0.7 | 3650 | 3649.98 | 0.767497 | 0.00182499
PLINTHE | 537 | +8.120 | +8.220 | GC8 | 0.4 | 1735 | 1734.99 | 0.365349 | 0.000867497
PLINTHE | 530 | +8.710 | +8.810 | GC6 | 0.2 | 1010 | 1009.99 | 0.213099 | 0.000504997
PLINTHE | 529 | +8.920 | +9.020 | GC3 | 0.2 | 845 | 845.004 | 0.178451 | 0.000422502
2 x PLINTHE | 529 | +8.920 | +9.020 | GC2 | 0.2 | 845 | 845 | 0.17845 | 0.0004225
PLINTHE | 529 | +8.920 | +9.020 | GC3 | 0.2 | 845 | 845 | 0.17845 | 0.0004225
PLINTHE | 529 | +8.920 | +9.020 | GC1 | 0.2 | 845 | 845 | 0.17845 | 0.0004225
PLINTHE | 532 | +8.710 | +8.810 | GC8 | 0.4 | 2550 | 2550 | 0.5365 | 0.001275
PLINTHE | 530 | +8.710 | +8.810 | GC7 | 0.2 | 1010 | 1009.99 | 0.213099 | 0.000504997
PLINTHE | 529 | +8.920 | +9.020 | GC3 | 0.2 | 845 | 845.001 | 0.17845 | 0.0004225

# IfcBeam: PL12*140, PLAT
In: Undefined
Description: PL12*140; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.525; Niveau haut: +7.658; Repère de pièce: 226; Repère d'assemblage: PS5; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL12*140; Nom: PLAT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 140 mm; Largeur: 12 mm; Longueur: 133 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 226
BaseQuantities - Length: 133 mm; OuterSurfaceArea: 0.043792 m2; NetVolume: 0.00022344 m3; NetWeight: 0 kg

# IfcBeam: PL12*250, PRESCELLEMENT
In: Undefined
Description: PL12*250; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.477; Niveau haut: +7.707; Repère de pièce: 229; Repère d'assemblage: PS5; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL12*250; Nom: PRESCELLEMENT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 250 mm; Largeur: 12 mm; Longueur: 230 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 229
BaseQuantities - Length: 230 mm; OuterSurfaceArea: 0.12652 m2; NetVolume: 0.00069 m3; NetWeight: 0 kg

# IfcBeam: PL12*300 (27)
In: Undefined
Description: PL12*300; Material: Undefined/S235-E24
Tekla Commun - Matériau: S235-E24; Profil: PL12*300
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 300 mm; Largeur: 12 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Finition | Phase | Classe | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
7 x PLATINE CONSOLE | +8.175 | +8.475 | 511 | C9 | GALVA | 3 | 8 | PLATINE CONSOLE | 0 | 0.2 | 300 | 0.1944 | 0.00108
6 x PLATINE | +7.050 | +7.062 | 510 | P4 | GALVA | 3 | 8 | PLATINE | 0.1 | 0.2 | 300 | 0.1944 | 0.00108
8 x PLATINE | +7.050 | +7.062 | 510 | P3 | GALVA | 3 | 8 | PLATINE | 0.1 | 0.2 | 300 | 0.1944 | 0.00108
3 x PRESCELLEMENT | +6.970 | +7.625 | 227 | PS6 |  | 1 | 3 | PRESCELLEMENT | 0 | 0.4 | 655 | 0.41592 | 0.002358
3 x PRESCELLEMENT | +6.965 | +7.395 | 228 | PS4 |  | 1 | 3 | PRESCELLEMENT | 0 | 0.4 | 430 | 0.27552 | 0.001548

# IfcBeam: PL15*190 (5)
In: Undefined
Description: PL15*190; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL15*190
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 190 mm; Largeur: 15 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PLATINE | +7.310 | +8.030 | 154 | T3 | PLATINE | 0.4 | 720 | 720 | 0.3009 | 0.002052
JARRET | +7.135 | +7.542 | 152 | T7 | JARRET | 0.7 | 1549.7 | 1549.71 | 0.641081 | 0.00441667
PLATINE | +7.130 | +8.030 | 139 | T7 | PLATINE | 0.4 | 900 | 900 | 0.3747 | 0.002565
JARRET | +7.135 | +7.542 | 152 | T1 | JARRET | 0.7 | 1549.7 | 1549.71 | 0.641081 | 0.00441667
PLATINE | +7.130 | +8.030 | 139 | T1 | PLATINE | 0.4 | 900 | 900 | 0.3747 | 0.002565

# IfcBeam: PL15*200 (7)
In: Undefined
Description: PL15*200; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.215; Niveau haut: +5.480; Repère de pièce: 199; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL15*200; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 200 mm; Largeur: 15 mm; Longueur: 265 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 199
BaseQuantities - NetWeight: 0 kg
Name | Repère d'assemblage | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x PLATINE | C12 | 264.998 | 0.119949 | 0.000794993
5 x PLATINE | C11 | 265 | 0.11995 | 0.000795

# IfcBeam: PL15*210 (2)
In: Undefined
Description: PL15*210; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 153; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL15*210; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 210 mm; Largeur: 15 mm; Longueur: 550 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 153
BaseQuantities - Length: 550 mm; OuterSurfaceArea: 0.2538 m2; NetVolume: 0.0017325 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage
PLATINE | +7.499 | +8.049 | T4
PLATINE | +7.497 | +8.047 | T5

# IfcBeam: PL15*300 (2)
In: Undefined
Description: PL15*300; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.200; Niveau haut: -0.185; Repère de pièce: 29; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL15*300; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface nette: 0.2 m2; Hauteur: 300 mm; Largeur: 15 mm; Longueur: 310 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 29
BaseQuantities - Length: 310 mm; OuterSurfaceArea: 0.2043 m2; NetVolume: 0.001395 m3; NetWeight: 0 kg
Name | Repère d'assemblage
PLATINE | PT10
PLATINE | PT12

# IfcBeam: PL15*490 (4)
In: Undefined
Description: PL15*490; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.200; Niveau haut: -0.185; Repère de pièce: 28; Classe: 2; Matériau: S235-E24; Profil: PL15*490; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface nette: 0.4 m2; Hauteur: 490 mm; Largeur: 15 mm; Longueur: 310 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 28
BaseQuantities - Length: 310 mm; OuterSurfaceArea: 0.3278 m2; NetVolume: 0.0022785 m3; NetWeight: 0 kg
Name | Repère d'assemblage | Phase
PLATINE | PT5 | 4
PLATINE | PT4 | 1
PLATINE | PT3 | 1
PLATINE | PT6 | 1

# IfcBeam: PL15*90 (44)
In: Undefined
Description: PL15*90; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL15*90; Nom: PLAQUETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 15 mm; Longueur: 90 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 90 mm; OuterSurfaceArea: 0.0216 m2; NetVolume: 0.0001215 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage
14 x PLAQUETTE | -0.185 | -0.170 | 41 | PS1
14 x PLAQUETTE | -0.580 | -0.565 | 34 | PS1
8 x PLAQUETTE | -0.185 | -0.170 | 41 | PS2
8 x PLAQUETTE | -0.580 | -0.565 | 34 | PS2

# IfcBeam: PL150*4 (7)
In: Undefined
Description: PL150*4; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.080; Niveau haut: +5.230; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL150*4; Nom: SUPPORT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 150 mm; Largeur: 4 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
SUPPORT | S50 | 0.2 | 515 | 0.15982 | 0.000309
SUPPORT | S49 | 0.7 | 2125 | 0.6557 | 0.001275
2 x SUPPORT | S46 | 1 | 2965 | 0.91442 | 0.001779
3 x SUPPORT | S45 | 1 | 3000 | 0.9252 | 0.0018

# IfcBeam: PL160*8, ATTACHE
In: Undefined
Description: PL160*8; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +4.830; Niveau haut: +4.940; Repère de pièce: A76; Repère d'assemblage: A76; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL160*8; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 160 mm; Largeur: 8 mm; Longueur: 164 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A76
BaseQuantities - Length: 164 mm; OuterSurfaceArea: 0.060352 m2; NetVolume: 0.00022016 m3; NetWeight: 0 kg

# IfcBeam: PL2*4000 (12)
In: Undefined
Description: PL2*4000; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL2*4000; Nom: POUTRE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Largeur: 2 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Hauteur (mm) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x POUTRE | +7.931 | +8.090 | A70 | 1.2 | 3791.9 | 176 | 1.33859 | 0.00132271
POUTRE | +7.931 | +8.090 | A2 | 1 | 3791.9 | 136 | 1.02828 | 0.00101256
2 x POUTRE | +7.811 | +7.970 | A70 | 1.2 | 3791.9 | 176 | 1.33859 | 0.00132271
POUTRE | +7.811 | +7.970 | A69 | 1 | 3791.9 | 136 | 1.03508 | 0.00101936
2 x POUTRE | +7.692 | +7.851 | A70 | 1.2 | 3791.9 | 176 | 1.33859 | 0.00132271
2 x POUTRE | +7.568 | +7.732 | A71 | 1.5 | 3947.3 | 176 | 1.37957 | 0.00136273
POUTRE | +7.692 | +7.851 | A69 | 1 | 3791.9 | 136 | 1.03508 | 0.00101936
POUTRE | +7.568 | +7.732 | A72 | 1.1 | 3947.3 | 136 | 1.06363 | 0.00104695

# IfcBeam: PL20*80, PLAT
In: Undefined
Description: PL20*80; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +3.255; Niveau haut: +3.375; Repère de pièce: 130; Repère d'assemblage: PS3; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL20*80; Nom: PLAT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 80 mm; Largeur: 20 mm; Longueur: 120 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 130
BaseQuantities - Length: 120 mm; OuterSurfaceArea: 0.0272 m2; NetVolume: 0.000192 m3; NetWeight: 0 kg

# IfcBeam: PL200*6 (3)
In: Undefined
Description: PL200*6; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: GC0(?); Repère d'assemblage: GC0(?); Finition: GALVA; Phase: 3; Classe: 4; Matériau: S235-E24; Profil: PL200*6; Nom: CACHE VIDE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 200 mm; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes; Reference: GC0(?)
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x CACHE VIDE | +8.110 | +8.116 | 0.3 | 0.7 | 1650 | 0.6822 | 0.00198
CACHE VIDE | +8.700 | +8.706 | 1.1 | 2.2 | 5350 | 2.2066 | 0.00642

# IfcBeam: PL3*1055, SUPPORT CHARGE BARDAG
In: Undefined
Description: PL3*1055; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.000; Niveau haut: +5.080; Repère de pièce: S26; Repère d'assemblage: S26; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL3*1055; Nom: SUPPORT CHARGE BARDAG
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.7 m2; Hauteur: 1055 mm; Largeur: 3 mm; Longueur: 378 mm
Pset_BeamCommon - LoadBearing: yes; Reference: S26
BaseQuantities - Length: 378 mm; OuterSurfaceArea: 0.818874 m2; NetVolume: 0.00121536 m3; NetWeight: 0 kg

# IfcBeam: PL3*1450 (2)
In: Undefined
Description: PL3*1450; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +2.784; Niveau haut: +2.840; Repère de pièce: F18; Repère d'assemblage: F18; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: PL3*1450; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 1450 mm; Largeur: 3 mm; Longueur: 159.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F18
BaseQuantities - Length: 159.306 mm; OuterSurfaceArea: 0.479917 m2; NetVolume: 0.000705366 m3; NetWeight: 0 kg

# IfcBeam: PL3*1550 (2)
In: Undefined
Description: PL3*1550; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: F14; Repère d'assemblage: F14; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL3*1550; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1 m2; Hauteur: 1550 mm; Largeur: 3 mm; Longueur: 285.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F14
BaseQuantities - Length: 285.25 mm; OuterSurfaceArea: 0.913922 m2; NetVolume: 0.00135431 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
FEUILLURE | +10.120 | +11.670
FEUILLURE | +8.570 | +10.120

# IfcBeam: PL3*1950 (2)
In: Undefined
Description: PL3*1950; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: F13; Repère d'assemblage: F13; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL3*1950; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1.1 m2; Hauteur: 1950 mm; Largeur: 3 mm; Longueur: 285.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F13
BaseQuantities - Length: 285.25 mm; OuterSurfaceArea: 1.14932 m2; NetVolume: 0.00170381 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
FEUILLURE | +8.570 | +10.520
FEUILLURE | +10.520 | +12.470

# IfcBeam: PL3*2280, FEUILLURE
In: Undefined
Description: PL3*2280; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.570; Niveau haut: +10.850; Repère de pièce: F15; Repère d'assemblage: F15; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL3*2280; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1.2 m2; Hauteur: 2280 mm; Largeur: 3 mm; Longueur: 285.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F15
BaseQuantities - Length: 285.25 mm; OuterSurfaceArea: 1.34353 m2; NetVolume: 0.00199215 m3; NetWeight: 0 kg

# IfcBeam: PL3*2515, SUPPORT CHARGE BARDAG
In: Undefined
Description: PL3*2515; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.000; Niveau haut: +5.080; Repère de pièce: S24; Repère d'assemblage: S24; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL3*2515; Nom: SUPPORT CHARGE BARDAG
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1.9 m2; Hauteur: 2515 mm; Largeur: 3 mm; Longueur: 378 mm
Pset_BeamCommon - LoadBearing: yes; Reference: S24
BaseQuantities - Length: 378 mm; OuterSurfaceArea: 1.94891 m2; NetVolume: 0.00289728 m3; NetWeight: 0 kg

# IfcBeam: PL3*3000 (4)
In: Undefined
Description: PL3*3000; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.000; Niveau haut: +5.080; Repère de pièce: S23; Repère d'assemblage: S23; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL3*3000; Nom: SUPPORT CHARGE BARDAG
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 2.3 m2; Hauteur: 3000 mm; Largeur: 3 mm; Longueur: 378 mm
Pset_BeamCommon - LoadBearing: yes; Reference: S23
BaseQuantities - Length: 378 mm; OuterSurfaceArea: 2.3243 m2; NetVolume: 0.003456 m3; NetWeight: 0 kg

# IfcBeam: PL3*3790 (12)
In: Undefined
Description: PL3*3790; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 6; Matériau: S235-E24; Profil: PL3*3790; Nom: PANNE SHED
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 3790 mm; Largeur: 3 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x PANNE SHED | +8.771 | +8.919 | PN21 | 0 | 3.1 | 394.9 | 394.935 | 3.07365 | 0.00457274
2 x PANNE SHED | +8.768 | +8.916 | PN20 | 0 | 3.1 | 394.9 | 394.862 | 3.07331 | 0.00457224
2 x PANNE SHED | +8.772 | +8.919 | PN21 | 0 | 3.1 | 394.9 | 394.949 | 3.07371 | 0.00457283
2 x PANNE SHED | +10.851 | +11.053 | PN34 | 0.3 | 3.5 | 448.2 | 448.194 | 3.48043 | 0.00518243
2 x PANNE SHED | +11.671 | +11.876 | PN33 | 0.3 | 3.5 | 449.6 | 449.551 | 3.49062 | 0.00519771
2 x PANNE SHED | +12.474 | +12.679 | PN33 | 0.3 | 3.5 | 449.8 | 449.806 | 3.49254 | 0.00520058

# IfcBeam: PL3*3950 (12)
In: Undefined
Description: PL3*3950; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 6; Matériau: S235-E24; Profil: PL3*3950; Nom: PANNE SHED
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 3950 mm; Largeur: 3 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PANNE SHED | +8.772 | +8.919 | PN32 | 0 | 3.2 | 394.9 | 394.949 | 3.20336 | 0.00476588
PANNE SHED | +8.771 | +8.919 | PN32 | 0 | 3.2 | 394.9 | 394.935 | 3.2033 | 0.00476578
PANNE SHED | +8.768 | +8.916 | PN31 | 0 | 3.2 | 394.9 | 394.862 | 3.20296 | 0.00476526
PANNE SHED | +10.851 | +11.053 | PN29 | 0.3 | 3.6 | 448.2 | 448.194 | 3.62724 | 0.00540121
PANNE SHED | +11.671 | +11.876 | PN28 | 0.3 | 3.6 | 449.6 | 449.551 | 3.63787 | 0.00541714
PANNE SHED | +12.474 | +12.679 | PN28 | 0.3 | 3.6 | 449.8 | 449.806 | 3.63986 | 0.00542013
PANNE SHED | +8.772 | +8.919 | PN23 | 0 | 3.2 | 394.9 | 394.949 | 3.20336 | 0.00476588
PANNE SHED | +8.771 | +8.919 | PN23 | 0 | 3.2 | 394.9 | 394.935 | 3.2033 | 0.00476578
PANNE SHED | +8.768 | +8.916 | PN22 | 0 | 3.2 | 394.9 | 394.862 | 3.20296 | 0.00476526
PANNE SHED | +10.851 | +11.053 | PN27 | 0.3 | 3.6 | 448.2 | 448.194 | 3.62724 | 0.00540121
PANNE SHED | +11.671 | +11.876 | PN26 | 0.3 | 3.6 | 449.6 | 449.551 | 3.63787 | 0.00541714
PANNE SHED | +12.474 | +12.679 | PN26 | 0.3 | 3.6 | 449.8 | 449.806 | 3.63986 | 0.00542013

# IfcBeam: PL3*70 (24)
In: Undefined
Description: PL3*70; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 551; Repère d'assemblage: M18; Finition: GALVA; Phase: 3; Classe: 3; Matériau: S235-E24; Profil: PL3*70; Nom: PLAT MARCHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 70 mm; Largeur: 3 mm; Longueur: 310 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 551
BaseQuantities - Length: 310 mm; OuterSurfaceArea: 0.0450382 m2; NetVolume: 0.0000642 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
6 x PLAT MARCHE | +8.630 | +8.700
6 x PLAT MARCHE | +8.450 | +8.520
6 x PLAT MARCHE | +8.270 | +8.340
6 x PLAT MARCHE | +8.090 | +8.160

# IfcBeam: PL30*990 (19)
In: Undefined
Description: PL30*990; Material: Undefined/S235-E24
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 3; Matériau: S235-E24; Profil: PL30*990; Nom: PALIER
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 990 mm; Largeur: 30 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PALIER | +8.670 | +8.700 | P6(?) | 0.8 | 1.7 | 810 | 810 | 1.7344 | 0.023892
8 x PALIER | +8.670 | +8.700 | P10(?) | 1 | 2.2 | 1050 | 1050 | 2.224 | 0.03102
2 x PALIER | +8.850 | +8.880 | P5(?) | 0.8 | 1.7 | 845 | 845 | 1.8058 | 0.0249315
4 x PALIER | +8.080 | +8.110 | P10(?) | 1 | 2.2 | 1050 | 1050 | 2.224 | 0.03102
2 x PALIER | +8.670 | +8.700 | P11(?) | 1.1 | 2.3 | 1090 | 1090 | 2.3056 | 0.032208
PALIER | +8.850 | +8.880 | P5(?) | 0.8 | 1.7 | 845 | 845.004 | 1.80581 | 0.0249316
PALIER | +8.670 | +8.700 | P8(?) | 1 | 2.1 | 990 | 990 | 2.1016 | 0.029238

# IfcBeam: PL30*994 (22)
In: Undefined
Description: PL30*994; Material: Undefined/S235-E24
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 3; Matériau: S235-E24; Profil: PL30*994; Nom: MARCHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.3 m2; Surface nette: 0.7 m2; Hauteur: 994 mm; Largeur: 30 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
3 x MARCHE | +8.130 | +8.160 | 616 | M18 | 310 | 0.69452 | 0.0092442
3 x MARCHE | +8.310 | +8.340 | 616 | M18 | 310 | 0.69452 | 0.0092442
3 x MARCHE | +8.490 | +8.520 | 616 | M18 | 310 | 0.69452 | 0.0092442
3 x MARCHE | +8.670 | +8.700 | 616 | M18 | 310 | 0.69452 | 0.0092442
2 x MARCHE | +7.480 | +7.510 | 576 | M37 | 290 | 0.65356 | 0.0086478
2 x MARCHE | +7.680 | +7.710 | 576 | M37 | 290 | 0.65356 | 0.0086478
2 x MARCHE | +8.277 | +8.307 | 576 | M37 | 290 | 0.65356 | 0.0086478
2 x MARCHE | +8.473 | +8.503 | 576 | M37 | 290 | 0.65356 | 0.0086478
2 x MARCHE | +7.880 | +7.910 | 576 | M37 | 290 | 0.65356 | 0.0086478

# IfcBeam: PL4*80 (28)
In: Undefined
Description: PL4*80; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.460; Niveau haut: +7.540; Repère de pièce: 579; Finition: GALVA; Phase: 3; Classe: 8; Matériau: S235-E24; Profil: PL4*80; Nom: BORD COLLERETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 80 mm; Largeur: 4 mm; Longueur: 200 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 579
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.03424 m2; NetVolume: 0.000064 m3; NetWeight: 0 kg
Name | Repère d'assemblage
12 x BORD COLLERETTE | P4
16 x BORD COLLERETTE | P3

# IfcBeam: PL5*100 (6)
In: Undefined
Description: PL5*100; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Matériau: S235-E24; Profil: PL5*100; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 5 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Classe | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
4 x ATTACHE | +5.340 | +5.440 | A77 | 3 | 130 | 129.999 | 0.0293499 | 0.0000674997
2 x ATTACHE | +8.410 | +8.470 | A13 | 2 | 220 | 220 | 0.04825 | 0.0001125

# IfcBeam: PL5*1120, FEUILLURE
In: Undefined
Description: PL5*1120; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +6.250; Niveau haut: +7.370; Repère de pièce: F2; Repère d'assemblage: F2; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*1120; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 1120 mm; Largeur: 5 mm; Longueur: 220 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F2
BaseQuantities - Length: 220 mm; OuterSurfaceArea: 0.51745 m2; NetVolume: 0.00126 m3; NetWeight: 0 kg

# IfcBeam: PL5*140 (6)
In: Undefined
Description: PL5*140; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*140; Nom: SUPPORT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 140 mm; Largeur: 5 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
SUPPORT | +7.860 | +7.932 | S19 | 110.5 | 110.529 | 0.0348586 | 0.0000807623
SUPPORT | +7.860 | +7.930 | S17 | 109.7 | 109.681 | 0.0347037 | 0.0000803883
SUPPORT | +7.741 | +7.813 | S19 | 110.5 | 110.529 | 0.0348586 | 0.0000807623
SUPPORT | +7.741 | +7.811 | S17 | 109.7 | 109.681 | 0.0347037 | 0.0000803883
SUPPORT | +7.622 | +7.693 | S19 | 110.5 | 110.529 | 0.0348586 | 0.0000807623
SUPPORT | +7.622 | +7.692 | S17 | 109.7 | 109.681 | 0.0347037 | 0.0000803883

# IfcBeam: PL5*157 (4)
In: Undefined
Description: PL5*157; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: G32; Repère d'assemblage: G32; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: PL5*157; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 156.7 mm; Largeur: 5 mm; Longueur: 169 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G32
BaseQuantities - Length: 168.971 mm; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | +2.481 | +2.650 | 0.0305038 | 0.000069914
GOUSSET | +2.481 | +2.650 | 0.030501 | 0.0000699076
2 x GOUSSET | -0.175 | -0.006 | 0.0305038 | 0.0000699141

# IfcBeam: PL5*1590, FEUILLURE
In: Undefined
Description: PL5*1590; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +6.250; Niveau haut: +7.840; Repère de pièce: F3; Repère d'assemblage: F3; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*1590; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.7 m2; Hauteur: 1590 mm; Largeur: 5 mm; Longueur: 220 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F3
BaseQuantities - Length: 220 mm; OuterSurfaceArea: 0.73365 m2; NetVolume: 0.00178875 m3; NetWeight: 0 kg

# IfcBeam: PL5*211 (4)
In: Undefined
Description: PL5*211; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: G30; Repère d'assemblage: G30; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: PL5*211; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 211.5 mm; Largeur: 5 mm; Longueur: 235.8 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G30
BaseQuantities - NetVolume: 0.000143103 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Length (mm) | OuterSurfaceArea (m2)
GOUSSET | +3.025 | +3.042 | 235.796 | 0.0608244
GOUSSET | +3.025 | +3.042 | 235.796 | 0.0608243
2 x GOUSSET | +2.834 | +2.851 | 235.797 | 0.0608245

# IfcBeam: PL5*2110 (2)
In: Undefined
Description: PL5*2110; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 144; Repère d'assemblage: PT2; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*2110; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.7 m2; Hauteur: 2110 mm; Largeur: 5 mm; Longueur: 160 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 144
BaseQuantities - Length: 160 mm; OuterSurfaceArea: 0.71905 m2; NetVolume: 0.00174075 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
FEUILLURE | +4.980 | +7.090
FEUILLURE | +2.870 | +4.980

# IfcBeam: PL5*2180 (2)
In: Undefined
Description: PL5*2180; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +6.250; Niveau haut: +8.430; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*2180; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1 m2; Hauteur: 2180 mm; Largeur: 5 mm; Longueur: 200 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 200 mm; NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference | OuterSurfaceArea (m2) | NetVolume (m3)
FEUILLURE | F12 | 0.86785 | 0.0021055
FEUILLURE | F7 | 0.89185 | 0.0021685

# IfcBeam: PL5*240 (2)
In: Undefined
Description: PL5*240; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: A12; Repère d'assemblage: A12; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*240; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 240 mm; Largeur: 5 mm; Longueur: 195.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A12
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
ATTACHE | +10.103 | +10.265 | 195.156 | 0.0989167 | 0.000236367
ATTACHE | +9.596 | +9.759 | 195.135 | 0.0989102 | 0.000236351

# IfcBeam: PL5*2500, FEUILLURE
In: Undefined
Description: PL5*2500; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +0.255; Niveau haut: +2.755; Repère de pièce: 149; Repère d'assemblage: PT2; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*2500; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1 m2; Hauteur: 2500 mm; Largeur: 5 mm; Longueur: 160 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 149
BaseQuantities - Length: 160 mm; OuterSurfaceArea: 0.85165 m2; NetVolume: 0.0020625 m3; NetWeight: 0 kg

# IfcBeam: PL5*300, GOUSSET
In: Undefined
Description: PL5*300; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +2.924; Niveau haut: +2.947; Repère de pièce: G31; Repère d'assemblage: G31; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: PL5*300; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.2 m2; Hauteur: 300.3 mm; Largeur: 5 mm; Longueur: 353.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G31
BaseQuantities - Length: 353.658 mm; OuterSurfaceArea: 0.213616 m2; NetVolume: 0.000518708 m3; NetWeight: 0 kg

# IfcBeam: PL5*3000 (8)
In: Undefined
Description: PL5*3000; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*3000; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 3000 mm; Largeur: 5 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
FEUILLURE | +3.250 | +6.250 | F11 | 1.2 | 200 | 1.25425 | 0.003054
FEUILLURE | +0.250 | +3.250 | F9 | 1.2 | 200 | 1.24645 | 0.003033
FEUILLURE | +3.250 | +6.250 | F10 | 1.2 | 200 | 1.25425 | 0.003054
FEUILLURE | +0.250 | +3.250 | F6 | 1.2 | 200 | 1.25425 | 0.003054
FEUILLURE | +3.250 | +6.250 | F1 | 1.5 | 220 | 1.38225 | 0.003375
FEUILLURE | +3.250 | +6.250 | F17 | 1.5 | 220 | 1.36725 | 0.0033375
2 x FEUILLURE | +0.250 | +3.250 | F1 | 1.5 | 220 | 1.38225 | 0.003375

# IfcBeam: PL5*350, FEUILLURE
In: Undefined
Description: PL5*350; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.080; Niveau haut: +8.430; Repère de pièce: F8; Repère d'assemblage: F8; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*350; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 350 mm; Largeur: 5 mm; Longueur: 230 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F8
BaseQuantities - Length: 230 mm; OuterSurfaceArea: 0.11975 m2; NetVolume: 0.000285 m3; NetWeight: 0 kg

# IfcBeam: PL5*560, FEUILLURE
In: Undefined
Description: PL5*560; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.860; Niveau haut: +8.420; Repère de pièce: F4; Repère d'assemblage: F4; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*560; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 560 mm; Largeur: 5 mm; Longueur: 235 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F4
BaseQuantities - Length: 235 mm; OuterSurfaceArea: 0.2768 m2; NetVolume: 0.000672 m3; NetWeight: 0 kg

# IfcBeam: PL5*581 (2)
In: Undefined
Description: PL5*581; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.450; Niveau haut: +8.540; Repère de pièce: 137; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*581; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 581 mm; Largeur: 5 mm; Longueur: 90 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 137
BaseQuantities - Length: 90 mm; OuterSurfaceArea: 0.11129 m2; NetVolume: 0.00026145 m3; NetWeight: 0 kg
Name | Repère d'assemblage
PLATINE | PT10
PLATINE | PT12

# IfcBeam: PL5*60 (8)
In: Undefined
Description: PL5*60; Material: Undefined/S235-E24
Tekla Commun - Finition: GALVA; Matériau: S235-E24; Profil: PL5*60
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 60 mm; Largeur: 5 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Nom | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MONTANT | +8.710 | +9.678 | 528 | GC8 | 3 | 4 | MONTANT | 0.1 | 967.6 | 0.12382 | 0.00028428
2 x MONTANT | +8.710 | +9.678 | 528 | GC10 | 3 | 4 | MONTANT | 0.1 | 967.6 | 0.12382 | 0.00028428
MONTANT | +8.710 | +9.678 | 528 | GC4 | 3 | 4 | MONTANT | 0.1 | 967.6 | 0.12382 | 0.00028428
2 x ATTACHE | +0.036 | +0.146 | A16 | A16 | 2 | 2 | ATTACHE | 0 | 247 | 0.03336 | 0.0000756
2 x ATTACHE | +1.376 | +1.486 | A16 | A16 | 2 | 2 | ATTACHE | 0 | 247 | 0.03336 | 0.0000756

# IfcBeam: PL5*620, FEUILLURE
In: Undefined
Description: PL5*620; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.390; Niveau haut: +8.010; Repère de pièce: F5; Repère d'assemblage: F5; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*620; Nom: FEUILLURE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 620 mm; Largeur: 5 mm; Longueur: 230 mm
Pset_BeamCommon - LoadBearing: yes; Reference: F5
BaseQuantities - Length: 230 mm; OuterSurfaceArea: 0.25265 m2; NetVolume: 0.0006105 m3; NetWeight: 0 kg

# IfcBeam: PL5*75 (9)
In: Undefined
Description: PL5*75; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 161; Repère d'assemblage: PT2; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*75; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 75 mm; Largeur: 5 mm; Longueur: 169.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 161
BaseQuantities - Length: 169.7 mm; OuterSurfaceArea: 0.0255279 m2; NetVolume: 0.0000579953 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
RAIDISSEUR | +6.033 | +6.038
RAIDISSEUR | +3.922 | +3.927
RAIDISSEUR | +1.503 | +1.508
RAIDISSEUR | +2.603 | +2.608
RAIDISSEUR | +0.402 | +0.407
RAIDISSEUR | +6.937 | +6.942
RAIDISSEUR | +5.128 | +5.133
RAIDISSEUR | +4.827 | +4.832
RAIDISSEUR | +3.018 | +3.023

# IfcBeam: PL5*90 (2)
In: Undefined
Description: PL5*90; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.450; Niveau haut: +8.540; Repère de pièce: 138; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL5*90; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 90 mm; Largeur: 5 mm; Longueur: 167.9 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 138
BaseQuantities - Length: 168 mm; OuterSurfaceArea: 0.0319028 m2; NetVolume: 0.0000736 m3; NetWeight: 0 kg
Name | Repère d'assemblage
RAIDISSEUR | PT10
RAIDISSEUR | PT12

# IfcBeam: PL50*1250 (3)
In: Undefined
Description: PL50*1250; Material: MISCELLANEOUS/POLYURETHANE
Tekla Commun - Niveau bas: +7.944; Niveau haut: +8.012; Repère de pièce: S55; Repère d'assemblage: S55; Phase: 3; Classe: 9; Matériau: POLYURETHANE; Profil: PL50*1250; Nom: STYRODUR
Tekla Quantités - Poids: 1.9 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 898.7 m2; Surface nette: 1.7 m2; Hauteur: 1250 mm; Largeur: 50 mm; Longueur: 600 mm
Pset_BeamCommon - LoadBearing: yes; Reference: S55
BaseQuantities - Length: 600 mm; OuterSurfaceArea: 1.685 m2; NetVolume: 0.0375 m3; NetWeight: 1.875 kg

# IfcBeam: PL50*500 (6)
In: Undefined
Description: PL50*500; Material: CONCRETE/BETON
Tekla Commun - Niveau bas: +7.995; Niveau haut: +8.061; Repère de pièce: DP1; Repère d'assemblage: DP1; Phase: 3; Classe: 1; Matériau: BETON; Profil: PL50*500; Nom: DALLE SUR PLOT
Tekla Quantités - Poids: 30 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface par tonne: 20 m2; Surface nette: 0.7 m2; Hauteur: 500 mm; Largeur: 50 mm; Longueur: 500 mm
Pset_BeamCommon - LoadBearing: yes; Reference: DP1
BaseQuantities - Length: 500 mm; OuterSurfaceArea: 0.6 m2; NetVolume: 0.0125 m3; NetWeight: 30 kg

# IfcBeam: PL6*120 (3)
In: Undefined
Description: PL6*120; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 469; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL6*120; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 120 mm; Largeur: 6 mm; Longueur: 64 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 469
BaseQuantities - Length: 64 mm; OuterSurfaceArea: 0.017568 m2; NetVolume: 0.00004608 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage
PLATINE | +7.565 | +7.573 | G10
PLATINE | +7.684 | +7.692 | G9
PLATINE | +7.804 | +7.812 | G8

# IfcBeam: PL6*150 (8)
In: Undefined
Description: PL6*150; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: A68; Repère d'assemblage: A68; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL6*150; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 150 mm; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A68
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
4 x ATTACHE | +9.803 | +9.925 | 185 | 0.0523029 | 0.00014595
4 x ATTACHE | +10.186 | +10.309 | 184.5 | 0.0521469 | 0.0001455

# IfcBeam: PL6*50 (30)
In: Undefined
Description: PL6*50; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL6*50; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 50 mm; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x ATTACHE | +7.907 | +8.073 | A67 | 330 | 330.012 | 0.0382125 | 0.000100748
5 x ATTACHE | +8.386 | +8.450 | A62 | 276.4 | 276.371 | 0.0328768 | 0.0000864557
ATTACHE | +8.083 | +8.193 | A66 | 274.4 | 274.384 | 0.0320245 | 0.0000841727
ATTACHE | +8.083 | +8.199 | A65 | 275.7 | 275.651 | 0.0321241 | 0.0000844396
ATTACHE | +8.202 | +8.312 | A66 | 274.4 | 274.394 | 0.0320255 | 0.0000841755
ATTACHE | +8.202 | +8.318 | A65 | 275.7 | 275.651 | 0.0321241 | 0.0000844396
4 x ATTACHE | +8.083 | +8.193 | A64 | 279 | 279.037 | 0.0325456 | 0.0000855686
4 x ATTACHE | +8.083 | +8.199 | A63 | 280 | 280.012 | 0.0326125 | 0.0000857478
4 x ATTACHE | +8.202 | +8.312 | A64 | 279 | 279.037 | 0.0325456 | 0.0000855686
4 x ATTACHE | +8.202 | +8.318 | A63 | 280 | 280.012 | 0.0326125 | 0.0000857478
3 x ATTACHE | +7.964 | +8.079 | A63 | 280 | 280.012 | 0.0326125 | 0.0000857478

# IfcBeam: PL60*10 (4)
In: Undefined
Description: PL60*10; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: A75; Repère d'assemblage: A75; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL60*10; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 10 mm; Longueur: 320 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A75
BaseQuantities - Length: 320 mm; OuterSurfaceArea: 0.0474 m2; NetVolume: 0.000198 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
ATTACHE | +2.660 | +2.800
3 x ATTACHE | +4.800 | +4.940

# IfcBeam: PL8*160 (14)
In: Undefined
Description: PL8*160; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 527; Finition: GALVA; Phase: 3; Classe: 8; Matériau: S235-E24; Profil: PL8*160; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 160 mm; Largeur: 8 mm; Longueur: 210 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 527
BaseQuantities - Length: 210 mm; OuterSurfaceArea: 0.0731198 m2; NetVolume: 0.000268799 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage
6 x PLATINE | +8.432 | +8.440 | P4
8 x PLATINE | +7.842 | +7.850 | P3

# IfcBeam: PL8*80 (6)
In: Undefined
Description: PL8*80; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.700; Niveau haut: +8.840; Repère de pièce: A80; Repère d'assemblage: A80; Finition: GALVA; Phase: 3; Classe: 2; Matériau: S235-E24; Profil: PL8*80; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 80 mm; Largeur: 8 mm; Longueur: 234 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A80
BaseQuantities - Length: 233.997 mm; OuterSurfaceArea: 0.0438714 m2; NetVolume: 0.000154878 m3; NetWeight: 0 kg

# IfcBeam: PL8*90 (20)
In: Undefined
Description: PL8*90; Material: Undefined/S235-E24
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 2; Matériau: S235-E24; Profil: PL8*90; Nom: PLAT LIMON
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 90 mm; Largeur: 8 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
3 x PLAT LIMON | +8.049 | +8.066 | 561 | L90 | 0.1 | 285.4 | 285.371 | 0.0573727 | 0.000205467
3 x PLAT LIMON | +8.066 | +8.181 | 552 | L90 | 0 | 115 | 114.997 | 0.0239795 | 0.000082798
3 x PLAT LIMON | +8.049 | +8.066 | 561 | L89 | 0.1 | 285.4 | 285.371 | 0.0573727 | 0.000205467
3 x PLAT LIMON | +8.066 | +8.181 | 552 | L89 | 0 | 115 | 114.997 | 0.0239795 | 0.000082798
PLAT LIMON | +7.370 | +7.378 | 524 | L33(?) | 0 | 237.7 | 237.733 | 0.0480357 | 0.000171168
PLAT LIMON | +7.378 | +7.525 | 523 | L33(?) | 0 | 147 | 147 | 0.030252 | 0.00010584
PLAT LIMON | +7.370 | +7.378 | 524 | L63 | 0 | 237.7 | 237.733 | 0.0480357 | 0.000171168
PLAT LIMON | +7.378 | +7.525 | 523 | L63 | 0 | 147 | 147 | 0.030252 | 0.00010584
PLAT LIMON | +7.370 | +7.378 | 524 | L5(?) | 0 | 237.7 | 237.733 | 0.0480357 | 0.000171168
PLAT LIMON | +7.378 | +7.525 | 523 | L5(?) | 0 | 147 | 147 | 0.030252 | 0.00010584
PLAT LIMON | +7.370 | +7.378 | 524 | L75(?) | 0 | 237.7 | 237.733 | 0.0480357 | 0.000171168
PLAT LIMON | +7.378 | +7.525 | 523 | L75(?) | 0 | 147 | 147 | 0.030252 | 0.00010584

# IfcBeam: TOLE10*149 (2)
In: Undefined
Description: TOLE10*149; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.220; Niveau haut: +5.230; Repère de pièce: 590; Repère d'assemblage: C12; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: TOLE10*149; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 149 mm; Largeur: 10 mm; Longueur: 200 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 590
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.045811 m2; NetVolume: 0.000199825 m3; NetWeight: 0 kg

# IfcBeam: TOLE10*180 (2)
In: Undefined
Description: TOLE10*180; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.200; Niveau haut: -0.190; Repère de pièce: 362; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: TOLE10*180; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 180 mm; Largeur: 10 mm; Longueur: 250 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 362
BaseQuantities - Length: 250 mm; OuterSurfaceArea: 0.0909042 m2; NetVolume: 0.000414 m3; NetWeight: 0 kg
Name | Repère d'assemblage
PLATINE | PT13
PLATINE | PT11

# IfcBeam: TOLE10*192 (24)
In: Undefined
Description: TOLE10*192; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 361; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE10*192; Nom: PLAT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 192.3 mm; Largeur: 10 mm; Longueur: 140 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 361
BaseQuantities - Length: 140 mm; OuterSurfaceArea: 0.0558591 m2; NetVolume: 0.000247678 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage
PLAT | +10.413 | +10.423 | M34
PLAT | +10.413 | +10.423 | M7
2 x PLAT | +10.413 | +10.423 | M8
2 x PLAT | +10.413 | +10.423 | M27
PLAT | +11.226 | +11.236 | M33
PLAT | +11.226 | +11.236 | M5
2 x PLAT | +11.226 | +11.236 | M6
2 x PLAT | +11.226 | +11.236 | M26
2 x PLAT | +10.413 | +10.423 | M29
2 x PLAT | +11.226 | +11.236 | M28
2 x PLAT | +12.027 | +12.037 | M4
2 x PLAT | +12.027 | +12.037 | M24
PLAT | +12.027 | +12.037 | M30
PLAT | +12.027 | +12.037 | M3
2 x PLAT | +12.027 | +12.037 | M25

# IfcBeam: TOLE10*260, PLATINE
In: Undefined
Description: TOLE10*260; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.462; Niveau haut: +7.722; Repère de pièce: 358; Repère d'assemblage: B5; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE10*260; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.2 m2; Hauteur: 260 mm; Largeur: 10 mm; Longueur: 316.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 358
BaseQuantities - Length: 316.727 mm; OuterSurfaceArea: 0.165061 m2; NetVolume: 0.00077349 m3; NetWeight: 0 kg

# IfcBeam: TOLE10*417 (2)
In: Undefined
Description: TOLE10*417; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.158; Niveau haut: +7.588; Repère de pièce: 357; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE10*417; Nom: JARRET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.7 m2; Hauteur: 416.5 mm; Largeur: 10 mm; Longueur: 1465.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 357
BaseQuantities - Length: 1465.39 mm; OuterSurfaceArea: 0.688162 m2; NetVolume: 0.00327529 m3; NetWeight: 0 kg
Name | Repère d'assemblage
JARRET | T7
JARRET | T1

# IfcBeam: TOLE10*60 (5)
In: Undefined
Description: TOLE10*60; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.220; Niveau haut: +5.230; Repère de pièce: 591; Repère d'assemblage: C11; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: TOLE10*60; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 10 mm; Longueur: 200 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 591
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.0237557 m2; NetVolume: 0.00009525 m3; NetWeight: 0 kg

# IfcBeam: TOLE15*250 (7)
In: Undefined
Description: TOLE15*250; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.230; Niveau haut: +5.480; Finition: GALVA; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: TOLE15*250; Nom: CONSOLE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 250 mm; Largeur: 15 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x CONSOLE | 597 | C12 | 0.4 | 599 | 0.255009 | 0.001737
5 x CONSOLE | 596 | C11 | 0.2 | 510 | 0.207839 | 0.00140325

# IfcBeam: TOLE3*70 (20)
In: Undefined
Description: TOLE3*70; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 580; Repère d'assemblage: M37; Finition: GALVA; Phase: 3; Classe: 3; Matériau: S235-E24; Profil: TOLE3*70; Nom: PLAT MARCHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 70 mm; Largeur: 3 mm; Longueur: 290 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 580
BaseQuantities - Length: 290 mm; OuterSurfaceArea: 0.0421182 m2; NetVolume: 0.00006 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
4 x PLAT MARCHE | +8.433 | +8.503
4 x PLAT MARCHE | +8.237 | +8.307
4 x PLAT MARCHE | +7.840 | +7.910
4 x PLAT MARCHE | +7.640 | +7.710
4 x PLAT MARCHE | +7.440 | +7.510

# IfcBeam: TOLE30*910 (12)
In: Undefined
Description: TOLE30*910; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.100; Niveau haut: +8.130; Phase: 1; Classe: 14; Matériau: S235-E24; Profil: TOLE30*910; Nom: CAILLEBOTIS
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 1.1 m2; Surface nette: 2.3 m2; Hauteur: 910 mm; Largeur: 30 mm; Longueur: 1180 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 1179.99 mm; NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference | OuterSurfaceArea (m2) | NetVolume (m3)
CAILLEBOTIS | CA4 | 2.28232 | 0.0318393
11 x CAILLEBOTIS | CA3 | 2.29605 | 0.0320453

# IfcBeam: TOLE30*940 (24)
In: Undefined
Description: TOLE30*940; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.100; Niveau haut: +8.130; Repère de pièce: CA1; Repère d'assemblage: CA1; Phase: 1; Classe: 14; Matériau: S235-E24; Profil: TOLE30*940; Nom: CAILLEBOTIS
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 1.1 m2; Surface nette: 2.5 m2; Hauteur: 940 mm; Largeur: 30 mm; Longueur: 1180 mm
Pset_BeamCommon - LoadBearing: yes; Reference: CA1
BaseQuantities - Length: 1179.99 mm; OuterSurfaceArea: 2.36865 m2; NetVolume: 0.0331073 m3; NetWeight: 0 kg

# IfcBeam: TOLE30*980 (12)
In: Undefined
Description: TOLE30*980; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.100; Niveau haut: +8.130; Repère de pièce: CA2; Repère d'assemblage: CA2; Phase: 1; Classe: 14; Matériau: S235-E24; Profil: TOLE30*980; Nom: CAILLEBOTIS
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 1.2 m2; Surface nette: 2.5 m2; Hauteur: 980 mm; Largeur: 30 mm; Longueur: 1180 mm
Pset_BeamCommon - LoadBearing: yes; Reference: CA2
BaseQuantities - Length: 1179.99 mm; OuterSurfaceArea: 2.46545 m2; NetVolume: 0.0345232 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*100, GOUSSET
In: Undefined
Description: TOLE6*100; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.465; Niveau haut: +7.566; Repère de pièce: 439; Repère d'assemblage: G10; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*100; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 100.3 mm; Largeur: 6 mm; Longueur: 200 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 439
BaseQuantities - Length: 199.86 mm; OuterSurfaceArea: 0.0241864 m2; NetVolume: 0.0000638559 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*109, GOUSSET
In: Undefined
Description: TOLE6*109; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.576; Niveau haut: +7.685; Repère de pièce: 438; Repère d'assemblage: G9; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*109; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 109 mm; Largeur: 6 mm; Longueur: 183.6 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 438
