Properties of the parts of a building model (IFC2X3), part 1 of 5

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: PoleAeroStructure.ifc
Time: 2018-09-14T00:36:55
Author: PORTCM01\professeur
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla Structures Educational 2017 Service Pack 2, IFC Export Version: 4.0.0.0 May 16 2017

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: 250*270, POUTRE
In: Undefined
Description: 250*270; Material: CONCRETE/C25/30
Tekla Commun - Niveau bas: -0.000; Niveau haut: +0.250; Repère de pièce: Po10; Repère d'assemblage: Po10; Phase: 1; Classe: 99; Matériau: C25/30; Profil: 250*270; Nom: POUTRE
Tekla Quantités - Poids: 81 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface par tonne: 8.1 m2; Surface nette: 0.7 m2; Hauteur: 250 mm; Largeur: 270 mm; Longueur: 500 mm
Pset_BeamCommon - LoadBearing: yes; Reference: Po10
BaseQuantities - Length: 500 mm; OuterSurfaceArea: 0.655 m2; NetVolume: 0.03375 m3; NetWeight: 81 kg

# IfcBeam: B140/150 (18)
In: Undefined
Description: B140/150; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: PN35; Repère d'assemblage: PN35; Phase: 1; Classe: 6; Matériau: S235-E24; Profil: B140/150; Nom: PANNE SHED
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 4.7 m2; Hauteur: 140 mm; Largeur: 56 mm; Longueur: 7750 mm
Pset_BeamCommon - LoadBearing: yes; Reference: PN35
BaseQuantities - Length: 7750 mm; OuterSurfaceArea: 0.00000456939 m2; NetVolume: 0.00341 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
2 x PANNE SHED | +9.458 | +9.608
2 x PANNE SHED | +9.487 | +9.637
2 x PANNE SHED | +10.227 | +10.377
2 x PANNE SHED | +10.170 | +10.320
2 x PANNE SHED | +10.966 | +11.116
2 x PANNE SHED | +11.756 | +11.906
2 x PANNE SHED | +11.004 | +11.154
2 x PANNE SHED | +10.252 | +10.402
2 x PANNE SHED | +9.500 | +9.650

# IfcBeam: D22 (22)
In: Undefined
Description: D22; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.600; Niveau haut: -0.250; Repère de pièce: 210; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: D22; Nom: TIGE D'ANCRAGE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 22 mm; Largeur: 22 mm; Longueur: 350 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 210
BaseQuantities - Length: 350 mm; OuterSurfaceArea: 0.0246409 m2; NetVolume: 0.00012705 m3; NetWeight: 0 kg
Name | Repère d'assemblage
14 x TIGE D'ANCRAGE | PS1
8 x TIGE D'ANCRAGE | PS2

# IfcBeam: D24 (22)
In: Undefined
Description: D24; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.250; Niveau haut: -0.100; Repère de pièce: 218; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: D24; Nom: TIGE D'ANCRAGE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 24 mm; Largeur: 24 mm; Longueur: 150 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 218
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.012045 m2; NetVolume: 0.0000648 m3; NetWeight: 0 kg
Name | Repère d'assemblage
14 x TIGE D'ANCRAGE | PS1
8 x TIGE D'ANCRAGE | PS2

# IfcBeam: HEA100, BECHE
In: Undefined
Description: HEA100; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: +3.267; Niveau haut: +3.363; Repère de pièce: 200; Repère d'assemblage: PS3; Phase: 1; Classe: 3; Matériau: S275-E28; Profil: HEA100; Nom: BECHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 96 mm; Largeur: 100 mm; Longueur: 100 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 200
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.0561 m2; NetVolume: 0.0002 m3; NetWeight: 0 kg

# IfcBeam: HEA120 (4)
In: Undefined
Description: HEA120; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: -0.330; Niveau haut: -0.210; Repère de pièce: 201; Repère d'assemblage: PS2; Phase: 1; Classe: 3; Matériau: S275-E28; Profil: HEA120; Nom: BECHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 114 mm; Largeur: 120 mm; Longueur: 120 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 201
BaseQuantities - Length: 120 mm; OuterSurfaceArea: 0.08124 m2; NetVolume: 0.0002892 m3; NetWeight: 0 kg

# IfcBeam: HEA140 (27)
In: Undefined
Description: HEA140; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Matériau: S275-E28; Profil: HEA140
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 133 mm; Largeur: 140 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Classe | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
LONGERON | +7.117 | +7.250 | L43 | L43 | 2 | LONGERON | 0.5 | 2.8 | 3465 | 2.75121 | 0.0104574
4 x LONGERON | +10.423 | +10.556 | L3 | L3 | 2 | LONGERON | 0.5 | 3 | 3650 | 2.8981 | 0.0110157
4 x LONGERON | +11.236 | +11.369 | L3 | L3 | 2 | LONGERON | 0.5 | 3 | 3650 | 2.8981 | 0.0110157
4 x LONGERON | +12.037 | +12.170 | L3 | L3 | 2 | LONGERON | 0.5 | 3 | 3650 | 2.8981 | 0.0110157
3 x BECHE | +7.018 | +7.151 | 32 | PS6 | 3 | BECHE | 0 | 0.1 | 100 | 0.0794 | 0.0003018
3 x BECHE | +7.443 | +7.576 | 32 | PS6 | 3 | BECHE | 0 | 0.1 | 100 | 0.0794 | 0.0003018
BECHE | +7.525 | +7.658 | 33 | PS5 | 3 | BECHE | 0 | 0.1 | 125 | 0.09925 | 0.00037725
3 x BECHE | +7.013 | +7.146 | 32 | PS4 | 3 | BECHE | 0 | 0.1 | 100 | 0.0794 | 0.0003018
3 x BECHE | +7.213 | +7.346 | 32 | PS4 | 3 | BECHE | 0 | 0.1 | 100 | 0.0794 | 0.0003018
LONGERON | +7.117 | +7.250 | L32 | L32 | 2 | LONGERON | 1.6 | 9.4 | 11545 | 9.16673 | 0.0348428

# IfcBeam: HEA180 (2)
In: Undefined
Description: HEA180; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: +7.079; Niveau haut: +7.250; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: HEA180; Nom: LONGERON
Tekla Quantités - Poids: 0 kg; Hauteur: 171 mm; Largeur: 180 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference | Volume (m3) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
LONGERON | L42 | 0 | 0.8 | 4 | 3690 | 3.77856 | 0.0159851
LONGERON | L40 | 0.1 | 2.1 | 12.1 | 11545 | 11.8221 | 0.0500129

# IfcBeam: HEA200 (6)
In: Undefined
Description: HEA200; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Classe: 2; Matériau: S275-E28; Profil: HEA200
Tekla Quantités - Poids: 0 kg; Hauteur: 190 mm; Largeur: 200 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Nom | Volume (m3) | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
LONGERON | +7.060 | +7.250 | L41 | LONGERON | 0 | 0.8 | 4.4 | 3765 | 4.27704 | 0.0192203
TRAVERSE HAUTE | +8.360 | +8.550 | TH2 | TRAVERSE HAUTE | 0 | 1.7 | 9.9 | 8515 | 9.67304 | 0.0434691
TRAVERSE BASSE | +5.000 | +5.190 | TB2 | TRAVERSE BASSE | 0 | 1.4 | 8.2 | 7055 | 8.01448 | 0.0360158
TRAVERSE HAUTE | +8.360 | +8.550 | TH1 | TRAVERSE HAUTE | 0 | 1.4 | 8.2 | 7055 | 8.01448 | 0.0360158
TRAVERSE BASSE | +5.000 | +5.190 | TB1 | TRAVERSE BASSE | 0 | 1.7 | 9.9 | 8515 | 9.67304 | 0.0434691
LONGERON | +7.060 | +7.250 | L39 | LONGERON | 0.1 | 2.3 | 13.5 | 11545 | 13.1151 | 0.0589372

# IfcBeam: IPE120 (7)
In: Undefined
Description: IPE120; Material: Undefined/S275-E28
Tekla Commun - Classe: 2; Matériau: S275-E28; Profil: IPE120; Nom: PANNE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 120 mm; Largeur: 64 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PANNE | +3.036 | +3.159 | PN37 | 2 | 5.2 | 10758 | 5.11005 | 0.0137591 | Tekla Commun - Finition: GALVA
PANNE | +2.936 | +3.059 | PN36 | 2 | 5.2 | 10758 | 5.11005 | 0.0137591 | Tekla Commun - Finition: GALVA
PANNE | +2.836 | +2.960 | PN11 | 2 | 5.2 | 10758 | 5.11005 | 0.0137591 | Tekla Commun - Finition: GALVA
PANNE | +7.451 | +7.573 | PN18 | 1 | 0.7 | 1125 | 0.534375 | 0.00143883
PANNE | +7.571 | +7.693 | PN10 | 1 | 0.7 | 1125 | 0.534375 | 0.00143883
PANNE | +7.690 | +7.812 | PN10 | 1 | 0.7 | 1125 | 0.534375 | 0.00143883
PANNE | +7.810 | +7.932 | PN10 | 1 | 0.7 | 1125 | 0.534375 | 0.00143883

# IfcBeam: IPE160 (4)
In: Undefined
Description: IPE160; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: +2.674; Niveau haut: +3.045; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S275-E28; Profil: IPE160; Nom: TRAVERSE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 2.6 m2; Hauteur: 160 mm; Largeur: 82 mm; Longueur: 4043.9 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 4043.91 mm; OuterSurfaceArea: 2.51935 m2; NetVolume: 0.0078273 m3; NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference
2 x TRAVERSE | T8
TRAVERSE | T6
TRAVERSE | T9

# IfcBeam: IPE180 (5)
In: Undefined
Description: IPE180; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE180; Nom: PANNE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 180 mm; Largeur: 91 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PANNE | +7.391 | +7.574 | PN16 | 2.7 | 3733.5 | 2.60598 | 0.00868113
PANNE | +7.510 | +7.693 | PN16 | 2.7 | 3733.5 | 2.60598 | 0.00868113
PANNE | +7.630 | +7.813 | PN16 | 2.7 | 3733.5 | 2.60598 | 0.00868113
PANNE | +7.749 | +7.932 | PN17 | 2.7 | 3733.5 | 2.60598 | 0.00868113
PANNE | +7.861 | +8.044 | PN2 | 2.8 | 3866.5 | 2.69882 | 0.00899039

# IfcBeam: IPE200 (20)
In: Undefined
Description: IPE200; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE200; Nom: PANNE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PANNE | +7.371 | +7.574 | PN9 | 4.1 | 5213.5 | 4.00397 | 0.0142057
PANNE | +7.490 | +7.693 | PN9 | 4.1 | 5213.5 | 4.00397 | 0.0142057
PANNE | +7.610 | +7.813 | PN9 | 4.1 | 5213.5 | 4.00397 | 0.0142057
PANNE | +7.729 | +7.932 | PN15 | 4.1 | 5213.5 | 4.00397 | 0.0142057
PANNE | +7.848 | +8.051 | PN8 | 4 | 5075 | 3.8976 | 0.0138284
PANNE | +7.371 | +7.574 | PN7 | 3.2 | 4023.5 | 3.09005 | 0.0109632
PANNE | +7.371 | +7.574 | PN5 | 3.2 | 4100 | 3.1488 | 0.0111717
PANNE | +7.490 | +7.693 | PN7 | 3.2 | 4023.5 | 3.09005 | 0.0109632
PANNE | +7.490 | +7.693 | PN5 | 3.2 | 4100 | 3.1488 | 0.0111717
PANNE | +7.610 | +7.813 | PN14 | 3.2 | 4023.5 | 3.09005 | 0.0109632
PANNE | +7.610 | +7.813 | PN13 | 3.2 | 4100 | 3.1488 | 0.0111717
PANNE | +7.729 | +7.932 | PN14 | 3.2 | 4023.5 | 3.09005 | 0.0109632
PANNE | +7.729 | +7.932 | PN13 | 3.2 | 4100 | 3.1488 | 0.0111717
PANNE | +7.848 | +8.051 | PN6 | 3 | 3790 | 2.91072 | 0.010327
PANNE | +7.848 | +8.051 | PN13 | 3.2 | 4100 | 3.1488 | 0.0111717
PANNE | +7.729 | +7.932 | PN4 | 3.1 | 3980 | 3.05664 | 0.0108447
PANNE | +7.610 | +7.813 | PN4 | 3.1 | 3980 | 3.05664 | 0.0108447
PANNE | +7.490 | +7.693 | PN4 | 3.1 | 3980 | 3.05664 | 0.0108447
PANNE | +7.371 | +7.574 | PN3 | 3.3 | 4165 | 3.19872 | 0.0113488
PANNE | +7.848 | +8.051 | PN12 | 3.3 | 4165 | 3.19872 | 0.0113488

# IfcBeam: IPE270 (2)
In: Undefined
Description: IPE270; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE270
Tekla Quantités - Poids: 0 kg; Surface supérieure totale: 0 m2; Hauteur: 270 mm; Largeur: 135 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Nom | Volume (m3) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PANNE | +7.778 | +8.052 | PN1 | PN1 | PANNE | 0 | 5.6 | 5260 | 5.47566 | 0.0231512
TRAVERSE | +7.297 | +8.039 | 11 | T3 | TRAVERSE | 0.1 | 16 | 15040.9 | 15.6576 | 0.0661631

# IfcBeam: IPE450 (3)
In: Undefined
Description: IPE450; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: +7.117; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE450; Nom: TRAVERSE
Tekla Quantités - Poids: 0 kg; Surface supérieure totale: 0 m2; Hauteur: 450 mm; Largeur: 190 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Volume (m3) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
TRAVERSE | +8.039 | 155 | T7 | 0.1 | 24.7 | 15046.6 | 24.1497 | 0.142861
TRAVERSE | +8.047 | T2 | T2 | 0.2 | 25.1 | 15291.1 | 24.5422 | 0.145252
TRAVERSE | +8.039 | 6 | T1 | 0.1 | 24.7 | 15046.6 | 24.1497 | 0.142861

# IfcBeam: IPE550 (2)
In: Undefined
Description: IPE550; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: +7.017; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE550; Nom: TRAVERSE
Tekla Quantités - Poids: 0 kg; Volume: 0.2 m3; Surface supérieure totale: 0 m2; Hauteur: 550 mm; Largeur: 210 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
TRAVERSE | +8.047 | 36 | T5 | 29.3 | 15264.8 | 28.652 | 0.197412
TRAVERSE | +8.049 | 35 | T4 | 29.4 | 15353.9 | 28.8192 | 0.198565

# IfcBeam: L100*10 (19)
In: Undefined
Description: L100*10; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L100*10; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
ATTACHE | +7.017 | +7.117 | A24 | A24 | 200 | 0.078 | 0.00038
ATTACHE | +7.104 | +7.225 | A23 | A23 | 120 | 0.0468 | 0.000228
ATTACHE | +6.979 | +7.079 | A19 | A19 | 200 | 0.078 | 0.00038
ATTACHE | +7.090 | +7.220 | A22 | A22 | 130 | 0.0507 | 0.000247
ATTACHE | +6.960 | +7.060 | A19 | A19 | 200 | 0.078 | 0.00038
2 x ATTACHE | +8.390 | +8.520 | A22 | A22 | 130 | 0.0507 | 0.000247
ATTACHE | +8.260 | +8.360 | 347 | A21 | 200 | 0.078 | 0.00038
2 x ATTACHE | +5.030 | +5.160 | A22 | A22 | 130 | 0.0507 | 0.000247
2 x ATTACHE | +4.900 | +5.000 | A19 | A19 | 200 | 0.078 | 0.00038
ATTACHE | +8.260 | +8.360 | 347 | A20 | 200 | 0.078 | 0.00038
2 x ATTACHE | +7.203 | +7.483 | A10 | A10 | 280 | 0.1092 | 0.000532
3 x ATTACHE | +7.970 | +8.210 | A11 | A11 | 240 | 0.0936 | 0.000456
ATTACHE | +7.343 | +7.523 | A9 | A9 | 180 | 0.0702 | 0.000342

# IfcBeam: L150*15 (10)
In: Undefined
Description: L150*15; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.200; Niveau haut: -0.050; Repère de pièce: A1; Repère d'assemblage: A1; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L150*15; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 150 mm; Largeur: 150 mm; Longueur: 200 mm
Pset_BeamCommon - LoadBearing: yes; Reference: A1
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.1172 m2; NetVolume: 0.000855 m3; NetWeight: 0 kg

# IfcBeam: L200*100*10 (87)
In: Undefined
Description: L200*100*10; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L200*100*10; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Hauteur (mm) | Largeur (mm) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
ATTACHE | +8.450 | +8.550 | A52 | 0.1 | 150 | 100 | 100 | 0.0587 | 0.00024
ATTACHE | +8.350 | +8.450 | A50 | 0.1 | 200 | 100 | 110 | 0.06457 | 0.000319
35 x ATTACHE | +8.350 | +8.450 | A46 | 0 | 200 | 100 | 60 | 0.03522 | 0.000174
ATTACHE | +8.350 | +8.450 | A49 | 0 | 192 | 100 | 60 | 0.03522 | 0.0001692
ATTACHE | +8.350 | +8.450 | A48 | 0 | 171 | 100 | 60 | 0.03522 | 0.0001566
ATTACHE | +8.350 | +8.450 | A47 | 0.1 | 200 | 100 | 110 | 0.06457 | 0.000319
2 x ATTACHE | +8.350 | +8.450 | A56 | 0.1 | 200 | 100 | 100 | 0.0587 | 0.00029
2 x ATTACHE | +8.440 | +8.510 | A57 | 0.1 | 200 | 70 | 100 | 0.0587 | 0.00026
ATTACHE | +7.143 | +7.224 | A51 | 0.1 | 200 | 100 | 80 | 0.04696 | 0.000232
8 x ATTACHE | +2.660 | +2.760 | A44 | 0 | 200 | 100 | 60 | 0.03522 | 0.000174
6 x ATTACHE | +4.350 | +4.450 | A44 | 0 | 200 | 100 | 60 | 0.03522 | 0.000174
11 x ATTACHE | +7.000 | +7.100 | A44 | 0 | 200 | 100 | 60 | 0.03522 | 0.000174
7 x ATTACHE | +0.900 | +1.000 | A44 | 0 | 200 | 100 | 60 | 0.03522 | 0.000174
5 x ATTACHE | +2.700 | +2.800 | A44 | 0 | 200 | 100 | 60 | 0.03522 | 0.000174
5 x ATTACHE | +4.800 | +4.900 | A44 | 0 | 200 | 100 | 60 | 0.03522 | 0.000174

# IfcBeam: L40*4 (7)
In: Undefined
Description: L40*4; Material: Undefined/S235-E24
Tekla Commun - Classe: 2; Matériau: S235-E24; Profil: L40*4
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 40 mm; Largeur: 40 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Finition | Phase | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x STABILITE CVT | +2.945 | +3.074 | S15 | GALVA | 2 | STABILITE CVT | 0.4 | 2209.6 | 2209.65 | 0.342495 | 0.000672644
3 x ATTACHE | +7.100 | +7.220 | A14 |  | 1 | ATTACHE | 0 | 120 | 120 | 0.0186 | 0.00003648
2 x STABILITE CVT | +2.846 | +2.977 | S15 | GALVA | 2 | STABILITE CVT | 0.4 | 2209.6 | 2209.65 | 0.342495 | 0.000672644

# IfcBeam: L50*5 (64)
In: Undefined
Description: L50*5; Material: Undefined/S235-E24
Tekla Commun - Classe: 2; Matériau: S235-E24; Profil: L50*5
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 50 mm; Largeur: 50 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
SUPPORT | +8.620 | +8.670 | S51 | 3 | SUPPORT | 0.3 | 1.1 | 5660 | 5660 | 1.09804 | 0.0026885 | Tekla Commun - Finition: GALVA
SUPPORT | +8.620 | +8.670 | S33 | 3 | SUPPORT | 0.3 | 1.1 | 5600 | 5600 | 1.0864 | 0.00266 | Tekla Commun - Finition: GALVA
3 x SUPPORT | +8.800 | +8.850 | S54 | 3 | SUPPORT | 0 | 0.1 | 705 | 705 | 0.13677 | 0.000334875 | Tekla Commun - Finition: GALVA
3 x SUPPORT | +8.800 | +8.850 | S53 | 3 | SUPPORT | 0 | 0.1 | 705 | 705 | 0.13677 | 0.000334875 | Tekla Commun - Finition: GALVA
SUPPORT | +8.620 | +8.670 | S25 | 3 | SUPPORT | 0.3 | 1.1 | 5660 | 5660 | 1.09804 | 0.0026885 | Tekla Commun - Finition: GALVA
4 x SUPPORT | +8.030 | +8.080 | S35 | 3 | SUPPORT | 0.1 | 0.4 | 2010 | 2010 | 0.38994 | 0.00095475 | Tekla Commun - Finition: GALVA
2 x SUPPORT | +8.620 | +8.670 | S52 | 3 | SUPPORT | 0 | 0.2 | 960 | 959.999 | 0.18624 | 0.000456 | Tekla Commun - Finition: GALVA
2 x SUPPORT | +8.620 | +8.670 | S36 | 3 | SUPPORT | 0 | 0.2 | 840 | 840 | 0.16296 | 0.000399 | Tekla Commun - Finition: GALVA
SUPPORT | +8.620 | +8.670 | S41 | 3 | SUPPORT | 0.3 | 1.1 | 5600 | 5600 | 1.0864 | 0.00266 | Tekla Commun - Finition: GALVA
LIERNE | +7.700 | +7.863 | L79 | 1 | LIERNE | 0 | 0.7 | 3874.7 | 3874.7 | 0.751691 | 0.00184143
LIERNE | +7.701 | +7.863 | L79 | 1 | LIERNE | 0 | 0.7 | 3874.7 | 3874.7 | 0.751691 | 0.00184143
LIERNE | +7.680 | +7.850 | L78 | 1 | LIERNE | 0 | 1 | 4309.7 | 4309.66 | 0.836074 | 0.00204804
LIERNE | +7.681 | +7.850 | L78 | 1 | LIERNE | 0 | 1 | 4309.7 | 4309.66 | 0.836074 | 0.00204804
LIERNE | +7.321 | +7.611 | L83 | 1 | LIERNE | 0 | 1.5 | 7646.8 | 7646.75 | 1.48347 | 0.00363316
3 x LIERNE | +7.561 | +7.852 | L80 | 1 | LIERNE | 0 | 1.5 | 7646.8 | 7646.75 | 1.48347 | 0.00363316
LIERNE | +7.341 | +7.631 | L82 | 1 | LIERNE | 0 | 1.5 | 7642.3 | 7642.25 | 1.4826 | 0.00363102
LIERNE | +7.581 | +7.864 | L81 | 1 | LIERNE | 0 | 1.5 | 7400 | 7399.96 | 1.43559 | 0.00351593
STABILITE CVT | +7.319 | +7.424 | S39 | 1 | STABILITE CVT | 0 | 0.4 | 2596.8 | 2596.85 | 0.503789 | 0.00123493
STABILITE CVT | +7.319 | +7.424 | S40 | 1 | STABILITE CVT | 0 | 0.4 | 2535 | 2535.02 | 0.491794 | 0.00120556
2 x LIERNE | +7.321 | +7.611 | L84 | 1 | LIERNE | 0 | 1.5 | 7646.8 | 7646.75 | 1.48347 | 0.00363316
STABILITE CVT | +7.439 | +7.544 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.71 | 0.488823 | 0.00119829
STABILITE CVT | +7.558 | +7.663 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.71 | 0.488823 | 0.00119829
STABILITE CVT | +7.677 | +7.783 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.71 | 0.488823 | 0.00119829
STABILITE CVT | +7.319 | +7.424 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.71 | 0.488823 | 0.00119829
LIERNE | +7.321 | +7.611 | L86 | 1 | LIERNE | 0 | 1.5 | 7646.8 | 7646.75 | 1.48347 | 0.00363316
LIERNE | +7.561 | +7.852 | L85 | 1 | LIERNE | 0 | 1.5 | 7646.8 | 7646.75 | 1.48347 | 0.00363316
STABILITE CVT | +7.375 | +7.538 | S38 | 1 | STABILITE CVT | 0 | 1.1 | 5256.2 | 5256.19 | 1.0197 | 0.00249812
STABILITE CVT | +7.378 | +7.483 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.7 | 0.488822 | 0.00119828
3 x SUPPORT | +8.050 | +8.100 | S37 | 1 | SUPPORT | 0.3 | 1.5 | 7470 | 7470 | 1.44918 | 0.00354825
3 x SUPPORT | +8.050 | +8.100 | S13 | 1 | SUPPORT | 0.3 | 1.5 | 7675 | 7675 | 1.48895 | 0.00364563
4 x STABILITE CVT | +9.504 | +10.439 | S8 | 1 | STABILITE CVT | 0 | 0.7 | 4071 | 4071.04 | 0.789781 | 0.00193469
4 x STABILITE CVT | +8.572 | +9.490 | S8 | 1 | STABILITE CVT | 0 | 0.7 | 4071 | 4071.04 | 0.789781 | 0.00193469
STABILITE CVT | +7.378 | +7.483 | S40 | 1 | STABILITE CVT | 0 | 0.4 | 2535 | 2535.03 | 0.491796 | 0.00120556
STABILITE CVT | +7.375 | +7.538 | S12 | 1 | STABILITE CVT | 0 | 1.1 | 5283.1 | 5283.05 | 1.02491 | 0.00251087
STABILITE CVT | +7.378 | +7.483 | S39 | 1 | STABILITE CVT | 0 | 0.4 | 2596.8 | 2596.86 | 0.50379 | 0.00123493
STABILITE CVT | +7.375 | +7.538 | S11 | 1 | STABILITE CVT | 0 | 1.1 | 5406.7 | 5406.7 | 1.0489 | 0.00256961
STABILITE CVT | +7.495 | +7.657 | S38 | 1 | STABILITE CVT | 0 | 1.1 | 5256.2 | 5256.19 | 1.0197 | 0.00249812
STABILITE CVT | +7.497 | +7.602 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.7 | 0.488822 | 0.00119828
STABILITE CVT | +7.614 | +7.777 | S38 | 1 | STABILITE CVT | 0 | 1.1 | 5256.2 | 5256.19 | 1.0197 | 0.00249811
STABILITE CVT | +7.617 | +7.722 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.69 | 0.488821 | 0.00119828
STABILITE CVT | +7.733 | +7.896 | S38(?) | 1 | STABILITE CVT | 0 | 1.1 | 5256.2 | 5256.2 | 1.0197 | 0.00249812
STABILITE CVT | +7.736 | +7.841 | S9 | 1 | STABILITE CVT | 0 | 0.4 | 2519.7 | 2519.71 | 0.488823 | 0.00119829

# IfcBeam: L60*6 (59)
In: Undefined
Description: L60*6; Material: Undefined/S235-E24
Tekla Commun - Classe: 2; Matériau: S235-E24; Profil: L60*6
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 60 mm; Largeur: 60 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
6 x ATTACHE | +8.440 | +8.500 | A29 | 3 | ATTACHE | 0 | 120 | 120 | 0.02796 | 0.00008208 | Tekla Commun - Finition: GALVA
8 x ATTACHE | +7.850 | +7.910 | A29 | 3 | ATTACHE | 0 | 120 | 120 | 0.02796 | 0.00008208 | Tekla Commun - Finition: GALVA
2 x ATTACHE | +8.480 | +8.660 | A45 | 3 | ATTACHE | 0 | 180 | 180 | 0.04194 | 0.00012312 | Tekla Commun - Finition: GALVA
3 x ATTACHE | +7.950 | +8.100 | A26 | 1 | ATTACHE | 0 | 150 | 150 | 0.03495 | 0.0001026
4 x STABILITE CVT | +8.589 | +9.892 | S7 | 1 | STABILITE CVT | 1.1 | 4471.9 | 4471.95 | 1.04196 | 0.00306018
4 x STABILITE CVT | +9.923 | +11.247 | S7 | 1 | STABILITE CVT | 1.1 | 4471.9 | 4471.95 | 1.04196 | 0.00306018
3 x STABILITE CVT | +8.568 | +10.263 | S6 | 1 | STABILITE CVT | 1.2 | 5017.9 | 5017.95 | 1.16918 | 0.00343364
4 x STABILITE CVT | +10.321 | +12.034 | S6 | 1 | STABILITE CVT | 1.2 | 5017.9 | 5017.95 | 1.16918 | 0.00343364
2 x ATTACHE | +7.846 | +7.912 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
2 x ATTACHE | +7.747 | +7.813 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
2 x ATTACHE | +7.736 | +7.802 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
2 x ATTACHE | +7.627 | +7.694 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
2 x ATTACHE | +7.617 | +7.683 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
2 x ATTACHE | +7.508 | +7.574 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
2 x ATTACHE | +7.497 | +7.564 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
2 x ATTACHE | +7.389 | +7.455 | A25 | 1 | ATTACHE | 0 | 200 | 200 | 0.0466 | 0.0001368
STABILITE CVT | +7.396 | +7.557 | S30 | 1 | STABILITE CVT | 0.7 | 3399.5 | 3399.54 | 0.792092 | 0.00232734
STABILITE CVT | +7.461 | +7.623 | S30 | 1 | STABILITE CVT | 0.7 | 3399.5 | 3399.54 | 0.792092 | 0.00232734
STABILITE CVT | +7.515 | +7.676 | S30 | 1 | STABILITE CVT | 0.7 | 3399.5 | 3399.54 | 0.792092 | 0.00232734
STABILITE CVT | +7.581 | +7.742 | S30 | 1 | STABILITE CVT | 0.7 | 3399.5 | 3399.54 | 0.792092 | 0.00232734
STABILITE CVT | +7.635 | +7.796 | S30 | 1 | STABILITE CVT | 0.7 | 3399.5 | 3399.54 | 0.792092 | 0.00232734
STABILITE CVT | +7.700 | +7.862 | S30 | 1 | STABILITE CVT | 0.7 | 3399.5 | 3399.54 | 0.792092 | 0.00232734
STABILITE CVT | +7.754 | +7.912 | S31 | 1 | STABILITE CVT | 0.7 | 3279.5 | 3279.54 | 0.764132 | 0.00224525
STABILITE CVT | +7.819 | +7.978 | S31 | 1 | STABILITE CVT | 0.7 | 3279.5 | 3279.54 | 0.764132 | 0.00224525
STABILITE CVT | +8.568 | +10.263 | S6 | 1 | STABILITE CVT | 1.2 | 5017.9 | 5017.94 | 1.16918 | 0.00343364

# IfcBeam: L70*7 (66)
In: Undefined
Description: L70*7; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Matériau: S235-E24; Profil: L70*7
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 70 mm; Largeur: 70 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Classe | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
SUPPORT | +5.010 | +5.080 | S10 | S10 | 2 | SUPPORT | 0 | 1.9 | 6735 | 6735 | 1.83192 | 0.00627028
SUPPORT | +5.010 | +5.080 | S32 | S32 | 2 | SUPPORT | 0.1 | 2.3 | 8195 | 8195 | 2.22904 | 0.00762954
SUPPORT | +1.030 | +1.100 | 495 | L25 | 2 | SUPPORT | 0.2 | 0.7 | 2155 | 2155 | 0.586159 | 0.0020063
SUPPORT | +4.930 | +5.000 | 494 | L55 | 2 | SUPPORT | 0.2 | 0.7 | 2940 | 2940 | 0.799681 | 0.00273714
SUPPORT | +1.030 | +1.100 | 493 | L2 | 2 | SUPPORT | 0.3 | 1.2 | 4240 | 4240 | 1.15328 | 0.00394744
12 x ATTACHE | +7.880 | +7.950 | A37 | A37 | 2 | ATTACHE | 0 | 0 | 140 | 140 | 0.03808 | 0.00013034
ATTACHE | +7.880 | +7.950 | A31 | A31 | 2 | ATTACHE | 0 | 0.1 | 180 | 180 | 0.04896 | 0.00016758
ATTACHE | +7.100 | +7.200 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +2.760 | +2.860 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +4.450 | +4.550 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +4.550 | +4.620 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +2.860 | +2.930 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +4.380 | +4.450 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +7.030 | +7.100 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | -0.100 | -0.030 | A36 | A36 | 2 | ATTACHE | 0 | 0 | 150 | 150 | 0.0408 | 0.00013965
ATTACHE | +2.690 | +2.760 | A30 | A30 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
3 x ATTACHE | +8.314 | +8.388 | A35 | A35 | 2 | ATTACHE | 0 | 0 | 130 | 130.004 | 0.0353611 | 0.000121034
3 x ATTACHE | +8.195 | +8.269 | A35 | A35 | 2 | ATTACHE | 0 | 0 | 130 | 130.004 | 0.0353611 | 0.000121034
ATTACHE | +0.930 | +1.000 | A34 | A34 | 2 | ATTACHE | 0 | 0 | 160 | 160 | 0.04352 | 0.00014896
ATTACHE | +7.030 | +7.100 | A34 | A34 | 2 | ATTACHE | 0 | 0 | 160 | 160 | 0.04352 | 0.00014896
ATTACHE | +2.730 | +2.800 | A34 | A34 | 2 | ATTACHE | 0 | 0 | 160 | 160 | 0.04352 | 0.00014896
ATTACHE | +4.830 | +4.900 | A34 | A34 | 2 | ATTACHE | 0 | 0 | 160 | 160 | 0.04352 | 0.00014896
ATTACHE | +2.690 | +2.760 | A33 | A33 | 2 | ATTACHE | 0 | 0 | 160 | 160 | 0.04352 | 0.00014896
SUPPORT | +2.790 | +2.860 | 380 | L29 | 3 | SUPPORT | 0.1 | 0.4 | 1900 | 1900 | 0.516799 | 0.0017689
SUPPORT | +1.030 | +1.100 | 379 | L24 | 2 | SUPPORT | 0.3 | 1.2 | 4625 | 4625 | 1.258 | 0.00430587
SUPPORT | +4.930 | +5.000 | 378 | L58 | 2 | SUPPORT | 0.2 | 0.7 | 3000 | 3000 | 0.815999 | 0.002793
SUPPORT | +2.790 | +2.860 | 380 | L23 | 2 | SUPPORT | 0.1 | 0.4 | 1900 | 1900 | 0.516799 | 0.0017689
SUPPORT | +1.030 | +1.100 | 377 | L21 | 2 | SUPPORT | 0.2 | 1 | 3040 | 3040 | 0.82688 | 0.00283024
SUPPORT | +4.930 | +5.000 | 376 | L52 | 2 | SUPPORT | 0.1 | 0.7 | 2140 | 2140.01 | 0.582081 | 0.00199234
3 x ATTACHE | +5.000 | +5.070 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
3 x ATTACHE | +7.030 | +7.100 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
3 x ATTACHE | +1.100 | +1.170 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
2 x ATTACHE | +2.730 | +2.800 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +2.690 | +2.760 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
2 x ATTACHE | +2.860 | +2.930 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
3 x ATTACHE | +4.870 | +4.940 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
ATTACHE | +2.900 | +2.970 | A32 | A32 | 2 | ATTACHE | 0 | 0 | 100 | 100 | 0.0272 | 0.0000931
2 x LISSE CHASSIS | +2.790 | +2.860 | 375 | L4 | 2 | LISSE CHASSIS | 0.3 | 1.1 | 3780 | 3780 | 1.02816 | 0.00351918
LISSE CHASSIS | +2.790 | +2.860 | 374 | L18 | 2 | LISSE CHASSIS | 0.2 | 1 | 3530 | 3530 | 0.96016 | 0.00326879
LISSE CHASSIS | +2.790 | +2.860 | 373 | L20 | 2 | LISSE CHASSIS | 0.2 | 1 | 3270 | 3270.01 | 0.889443 | 0.00304438

# IfcBeam: L80*8 (38)
In: Undefined
Description: L80*8; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Matériau: S235-E24; Profil: L80*8; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 80 mm; Largeur: 80 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Classe | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
14 x ATTACHE | +5.370 | +5.450 | A78 | 3 | 0 | 100 | 0.0311 | 0.0001216
14 x ATTACHE | +5.230 | +5.310 | A79 | 3 | 0.1 | 200 | 0.0622 | 0.0002432
2 x ATTACHE | +8.110 | +8.210 | A18 | 2 | 0 | 100 | 0.0311 | 0.0001216
2 x ATTACHE | +7.768 | +7.852 | A15 | 2 | 0 | 120 | 0.03732 | 0.00014592
2 x ATTACHE | +7.290 | +7.374 | A15 | 2 | 0 | 120 | 0.03732 | 0.00014592
ATTACHE | +7.838 | +7.922 | A17 | 2 | 0 | 120 | 0.03732 | 0.00014592
ATTACHE | +7.600 | +7.683 | A17 | 2 | 0 | 120 | 0.03732 | 0.00014592
ATTACHE | +7.719 | +7.803 | A17 | 2 | 0 | 120 | 0.03732 | 0.00014592
ATTACHE | +3.255 | +3.375 | A8 | 2 | 0 | 120 | 0.03732 | 0.00014592

# IfcBeam: PL1*1065 (3)
In: Undefined
Description: PL1*1065; Material: Undefined/S235-E24
Tekla Commun - Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*1065; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 1065 mm; Largeur: 1 mm; Longueur: 229.1 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 229.098 mm; OuterSurfaceArea: 0.505241 m2; NetVolume: 0.000251319 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference
COIFFE | +8.659 | +8.740 | C5(?)
2 x COIFFE | +8.069 | +8.150 | C5

# IfcBeam: PL1*20000 (2)
In: Undefined
Description: PL1*20000; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: X1; Repère d'assemblage: X1; Phase: 2; Classe: 6; Matériau: S235-E24; Profil: PL1*20000; Nom: BAVETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 7 m2; Hauteur: 20000 mm; Largeur: 1 mm; Longueur: 167.9 mm
Pset_BeamCommon - LoadBearing: yes; Reference: X1
BaseQuantities - Length: 167.904 mm; OuterSurfaceArea: 7.03146 m2; NetVolume: 0.00349555 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
BAVETTE | +4.450 | +4.555
BAVETTE | +2.800 | +2.905

# IfcBeam: PL1*283 (2)
In: Undefined
Description: PL1*283; Material: Undefined/S235-E24
Pset_BeamCommon - LoadBearing: yes; Reference: C0(?)
Tekla Commun - Niveau bas: +8.490; Niveau haut: +8.593; Repère de pièce: C0(?); Repère d'assemblage: C0(?); Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*283; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 283 mm; Largeur: 1 mm; Longueur: 233.1 mm
BaseQuantities - Length: 233.121 mm; OuterSurfaceArea: 0.133542 m2; NetVolume: 0.0000662538 m3; NetWeight: 0 kg

# IfcBeam: PL1*3000 (2)
In: Undefined
Description: PL1*3000; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.485; Niveau haut: +8.600; Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*3000; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 3000 mm; Largeur: 1 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
COIFFE | C8(?) | 4.4 | 718.7 | 718.69 | 4.3618 | 0.00217718
COIFFE | C7(?) | 4.7 | 788.7 | 788.68 | 4.70364 | 0.00234807

# IfcBeam: PL1*3045, COIFFE
In: Undefined
Description: PL1*3045; Material: Undefined/S235-E24
Pset_BeamCommon - LoadBearing: yes; Reference: C4(?)
Tekla Commun - Niveau bas: +8.490; Niveau haut: +8.600; Repère de pièce: C4(?); Repère d'assemblage: C4(?); Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*3045; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 4 m2; Hauteur: 3045 mm; Largeur: 1 mm; Longueur: 653.7 mm
BaseQuantities - Length: 653.71 mm; OuterSurfaceArea: 4.03135 m2; NetVolume: 0.00201197 m3; NetWeight: 0 kg

# IfcBeam: PL1*3585, COIFFE
In: Undefined
Description: PL1*3585; Material: Undefined/S235-E24
Pset_BeamCommon - LoadBearing: yes; Reference: C0(?)
Tekla Commun - Niveau bas: +8.490; Niveau haut: +8.593; Repère de pièce: C0(?); Repère d'assemblage: C0(?); Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*3585; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1.7 m2; Hauteur: 3585 mm; Largeur: 1 mm; Longueur: 233.1 mm
BaseQuantities - Length: 233.121 mm; OuterSurfaceArea: 1.68622 m2; NetVolume: 0.000839292 m3; NetWeight: 0 kg

# IfcBeam: PL1*419, COIFFE
In: Undefined
Description: PL1*419; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.490; Niveau haut: +8.593; Repère de pièce: C0(?); Repère d'assemblage: C0(?); Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*419; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.2 m2; Hauteur: 419 mm; Largeur: 1 mm; Longueur: 233.1 mm
Pset_BeamCommon - LoadBearing: yes; Reference: C0(?)
BaseQuantities - Length: 233.121 mm; OuterSurfaceArea: 0.197492 m2; NetVolume: 0.000098093 m3; NetWeight: 0 kg

# IfcBeam: PL1*4540, COIFFE
In: Undefined
Description: PL1*4540; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.490; Niveau haut: +8.600; Repère de pièce: C4(?); Repère d'assemblage: C4(?); Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*4540; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 6 m2; Hauteur: 4540 mm; Largeur: 1 mm; Longueur: 653.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: C4(?)
BaseQuantities - Length: 653.71 mm; OuterSurfaceArea: 6.00997 m2; NetVolume: 0.00299978 m3; NetWeight: 0 kg

# IfcBeam: PL1*4921.5, COIFFE
In: Undefined
Description: PL1*4921.5; Material: Undefined/S235-E24
Pset_BeamCommon - LoadBearing: yes; Reference: C0(?)
Tekla Commun - Niveau bas: +8.490; Niveau haut: +8.593; Repère de pièce: C0(?); Repère d'assemblage: C0(?); Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*4921.5; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 2.3 m2; Hauteur: 4921.5 mm; Largeur: 1 mm; Longueur: 233.1 mm
BaseQuantities - Length: 233.121 mm; OuterSurfaceArea: 2.31468 m2; NetVolume: 0.00115218 m3; NetWeight: 0 kg

# IfcBeam: PL1*6000, COIFFE
In: Undefined
Description: PL1*6000; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.485; Niveau haut: +8.600; Repère de pièce: C6; Repère d'assemblage: C6; Finition: X; Phase: 3; Classe: 6; Matériau: S235-E24; Profil: PL1*6000; Nom: COIFFE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 7 m2; Hauteur: 6000 mm; Largeur: 1 mm; Longueur: 698.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: C6
BaseQuantities - Length: 698.693 mm; OuterSurfaceArea: 6.90223 m2; NetVolume: 0.00344446 m3; NetWeight: 0 kg

# IfcBeam: PL10*100, PLAT
In: Undefined
Description: PL10*100; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +3.267; Niveau haut: +3.363; Repère de pièce: 119; Repère d'assemblage: PS3; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL10*100; Nom: PLAT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 100 mm; Largeur: 10 mm; Longueur: 96 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 119
BaseQuantities - Length: 96 mm; OuterSurfaceArea: 0.02312 m2; NetVolume: 0.000096 m3; NetWeight: 0 kg

# IfcBeam: PL10*110 (6)
In: Undefined
Description: PL10*110; Material: Undefined/S235-E24
Tekla Commun - Niveau haut: +7.565; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*110; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 110 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Repère de pièce = Reference | Repère d'assemblage | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
4 x RAIDISSEUR | +7.017 | 111 | S1 | 547.7 | 547.663 | 0.0839134 | 0.000358913
2 x RAIDISSEUR | +7.117 | 112 | S2 | 447.6 | 447.613 | 0.0689904 | 0.000294216

# IfcBeam: PL10*120 (8)
In: Undefined
Description: PL10*120; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: E3; Repère d'assemblage: E3; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*120; Nom: ECLISSE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 120 mm; Largeur: 10 mm; Longueur: 410 mm
Pset_BeamCommon - LoadBearing: yes; Reference: E3
BaseQuantities - Length: 410 mm; OuterSurfaceArea: 0.109 m2; NetVolume: 0.000492 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
2 x ECLISSE | +7.105 | +7.225
2 x ECLISSE | +7.095 | +7.215
2 x ECLISSE | +8.395 | +8.515
2 x ECLISSE | +5.035 | +5.155

# IfcBeam: PL10*133 (19)
In: Undefined
Description: PL10*133; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*133
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 133 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
PLATINE | +8.048 | +8.062 | 279 | M36 | PLATINE | 0 | 0 | 146.1 | 146.069 | 0.0444358 | 0.000194272
PLATINE | +7.250 | +7.260 | 288 | M34 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +7.250 | +7.260 | 288 | M29 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +8.450 | +8.460 | 289 | M7 | PLATINE | 0 | 0.1 | 180 | 180 | 0.05414 | 0.0002394
ECLISSE | +7.107 | +7.117 | E4 | E4 | ECLISSE | 0.1 | 0.1 | 410 | 410 | 0.11992 | 0.0005453
PLATINE | +8.550 | +8.560 | 288 | M3 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +8.550 | +8.560 | 288 | M5 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
ECLISSE | +7.069 | +7.079 | E4 | E4 | ECLISSE | 0.1 | 0.1 | 410 | 410 | 0.11992 | 0.0005453
PLATINE | +7.250 | +7.260 | 288 | M33 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +7.250 | +7.260 | 288 | M28 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +7.250 | +7.260 | 288 | M27 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +7.250 | +7.260 | 295 | M8 | PLATINE | 0.1 | 0.1 | 410 | 410 | 0.11992 | 0.0005453
PLATINE | +7.250 | +7.260 | 288 | M26 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +7.250 | +7.260 | 295 | M6 | PLATINE | 0.1 | 0.1 | 410 | 410 | 0.11992 | 0.0005453
ECLISSE | +7.050 | +7.060 | E4 | E4 | ECLISSE | 0.1 | 0.1 | 410 | 410 | 0.11992 | 0.0005453
PLATINE | +7.250 | +7.260 | 288 | M24 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +7.250 | +7.260 | 295 | M4 | PLATINE | 0.1 | 0.1 | 410 | 410 | 0.11992 | 0.0005453
PLATINE | +7.250 | +7.260 | 288 | M30 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266
PLATINE | +7.250 | +7.260 | 288 | M25 | PLATINE | 0 | 0.1 | 200 | 200 | 0.05986 | 0.000266

# IfcBeam: PL10*135 (3)
In: Undefined
Description: PL10*135; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*135
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 135 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
JARRET | +7.320 | +7.722 | 273 | T3 | JARRET | 0.4 | 1549.7 | 1549.71 | 0.452116 | 0.00209211
ATTACHE | +7.196 | +7.299 | A7 | A7 | ATTACHE | 0.1 | 180.6 | 180.619 | 0.0578897 | 0.000256918
COIFFE | +8.030 | +8.055 | 135 | PT4 | COIFFE | 0.1 | 484.2 | 484.239 | 0.143129 | 0.000653723

# IfcBeam: PL10*140 (29)
In: Undefined
Description: PL10*140; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Matériau: S235-E24; Profil: PL10*140
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 140 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Classe | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
ATTACHE | +7.633 | +7.763 | A4 | A4 | 2 | ATTACHE | 0.1 | 239.4 | 239.362 | 0.0668841 | 0.000299553
ATTACHE | +7.172 | +7.306 | A3 | A3 | 2 | ATTACHE | 0.1 | 240.6 | 240.619 | 0.0670727 | 0.000300433
PLATINE | +10.335 | +10.548 | 284 | TS9 | 2 | PLATINE | 0.1 | 213.4 | 213.395 | 0.0668184 | 0.000298752
PLATINE | +11.145 | +11.361 | 283 | TS4 | 2 | PLATINE | 0.1 | 215.7 | 215.685 | 0.0675054 | 0.000301958
PLATINE | +10.335 | +10.548 | 284 | TS8 | 2 | PLATINE | 0.1 | 213.4 | 213.395 | 0.0668184 | 0.000298752
PLATINE | +11.145 | +11.361 | 283 | TS3 | 2 | PLATINE | 0.1 | 215.7 | 215.685 | 0.0675054 | 0.000301958
PLATINE | +10.335 | +10.548 | 284 | TS7 | 2 | PLATINE | 0.1 | 213.4 | 213.395 | 0.0668184 | 0.000298752
PLATINE | +11.145 | +11.361 | 283 | TS2 | 2 | PLATINE | 0.1 | 215.7 | 215.685 | 0.0675054 | 0.000301958
PLATINE | +10.335 | +10.548 | 284 | TS6 | 2 | PLATINE | 0.1 | 213.4 | 213.395 | 0.0668184 | 0.000298752
PLATINE | +11.145 | +11.361 | 283 | TS1 | 2 | PLATINE | 0.1 | 215.7 | 215.685 | 0.0675054 | 0.000301958
PLATINE | +10.335 | +10.548 | 284 | TS10 | 2 | PLATINE | 0.1 | 213.4 | 213.395 | 0.0668184 | 0.000298752
PLATINE | +11.145 | +11.361 | 283 | TS5 | 2 | PLATINE | 0.1 | 215.7 | 215.685 | 0.0675054 | 0.000301958
PLATINE | +11.901 | +12.161 | 286 | TS15 | 2 | PLATINE | 0.1 | 259.8 | 259.795 | 0.0807386 | 0.000363714
PLATINE | +11.901 | +12.161 | 286 | TS13 | 2 | PLATINE | 0.1 | 259.8 | 259.795 | 0.0807386 | 0.000363714
PLATINE | +11.901 | +12.161 | 286 | TS12 | 2 | PLATINE | 0.1 | 259.8 | 259.795 | 0.0807386 | 0.000363714
PLATINE | +11.901 | +12.161 | 286 | TS11 | 2 | PLATINE | 0.1 | 259.8 | 259.795 | 0.0807386 | 0.000363714
PLATINE | +11.901 | +12.161 | 286 | TS14 | 2 | PLATINE | 0.1 | 259.8 | 259.795 | 0.0807386 | 0.000363714
3 x PLAT | +7.018 | +7.151 | 129 | PS6 | 3 | PLAT | 0 | 133 | 133 | 0.0427 | 0.0001862
3 x PLAT | +7.443 | +7.576 | 129 | PS6 | 3 | PLAT | 0 | 133 | 133 | 0.0427 | 0.0001862
3 x PLAT | +7.013 | +7.146 | 129 | PS4 | 3 | PLAT | 0 | 133 | 133 | 0.0427 | 0.0001862
3 x PLAT | +7.213 | +7.346 | 129 | PS4 | 3 | PLAT | 0 | 133 | 133 | 0.0427 | 0.0001862

# IfcBeam: PL10*141 (2)
In: Undefined
Description: PL10*141; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +2.906; Niveau haut: +3.213; Repère de pièce: 496; Repère d'assemblage: G11; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: PL10*141; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.2 m2; Hauteur: 141.2 mm; Largeur: 10 mm; Longueur: 732.8 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 496
BaseQuantities - Length: 732.76 mm; OuterSurfaceArea: 0.167426 m2; NetVolume: 0.000757476 m3; NetWeight: 0 kg

# IfcBeam: PL10*150 (11)
In: Undefined
Description: PL10*150; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: -0.210; Niveau haut: -0.200; Repère de pièce: 42; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL10*150; Nom: PRESCELLEMENT PS24
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface nette: 0.1 m2; Hauteur: 150 mm; Largeur: 10 mm; Longueur: 350 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 42
BaseQuantities - Length: 350 mm; OuterSurfaceArea: 0.115094 m2; NetVolume: 0.000523 m3; NetWeight: 0 kg
Name | Repère d'assemblage
7 x PRESCELLEMENT PS24 | PS1
4 x PRESCELLEMENT PS24 | PS2

# IfcBeam: PL10*155 (2)
In: Undefined
Description: PL10*155; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.117; Niveau haut: +7.272; Repère de pièce: 115; Repère d'assemblage: S5; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*155; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 155 mm; Largeur: 10 mm; Longueur: 170 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 115
BaseQuantities - Length: 170 mm; OuterSurfaceArea: 0.0370421 m2; NetVolume: 0.000157749 m3; NetWeight: 0 kg

# IfcBeam: PL10*160 (66)
In: Undefined
Description: PL10*160
Tekla Commun - Profil: PL10*160
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 160 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Material | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Matériau | Nom | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
4 x PLATINE | Undefined/S275-E28 | +2.800 | +3.050 | 500 | G29 | 2 | 2 | S275-E28 | PLATINE | 0.1 | 250 | 0.0882 | 0.0004 | Tekla Commun - Finition: GALVA
2 x PLATINE | Undefined/S275-E28 | +4.180 | +4.430 | 500 | G28 | 2 | 2 | S275-E28 | PLATINE | 0.1 | 250 | 0.0882 | 0.0004 | Tekla Commun - Finition: GALVA
5 x PANNE SHED | Undefined/S235-E24 | +8.619 | +8.920 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +10.024 | +10.325 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +10.823 | +11.120 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +8.626 | +8.923 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +9.344 | +9.642 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +9.312 | +9.612 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +10.084 | +10.381 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +11.614 | +11.911 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +10.862 | +11.159 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +10.110 | +10.407 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +9.358 | +9.655 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752
5 x PANNE SHED | Undefined/S235-E24 | +8.627 | +8.924 | 267 | PN19 | 1 | 6 | S235-E24 | PANNE SHED | 0.2 | 460 | 0.163 | 0.000752

# IfcBeam: PL10*170 (4)
In: Undefined
Description: PL10*170; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*170; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 170 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x RAIDISSEUR | +7.079 | +7.274 | 114 | S4 | 195 | 194.999 | 0.045329 | 0.000195749
2 x RAIDISSEUR | +7.060 | +7.275 | 113 | S3 | 215 | 214.999 | 0.0494843 | 0.000214749

# IfcBeam: PL10*190 (4)
In: Undefined
Description: PL10*190; Material: Undefined/S235-E24
Tekla Commun - Classe: 2; Matériau: S235-E24; Profil: PL10*190
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 190 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Nom | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
COIFFE | +8.030 | +8.055 | 133 | PT5 | 4 | COIFFE | 0.2 | 484.2 | 484.239 | 0.197496 | 0.000920054
2 x ATTACHE | +7.016 | +7.119 | A6 | A6 | 1 | ATTACHE | 0.1 | 180.6 | 180.619 | 0.0799237 | 0.000361588
COIFFE | +8.030 | +8.055 | 133 | PT6 | 1 | COIFFE | 0.2 | 484.2 | 484.239 | 0.197496 | 0.000920054

# IfcBeam: PL10*200 (26)
In: Undefined
Description: PL10*200; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Matériau: S235-E24; Profil: PL10*200
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 200 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Classe | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x CONTRE PLATINE | +5.215 | +5.480 | CP1 | CP1 | 3 | CONTRE PLATINE | 0 | 0.1 | 265 | 264.998 | 0.115299 | 0.000529995 | Tekla Commun - Finition: GALVA
2 x PLATINE | +8.350 | +8.360 | 272 | M20 | 2 | PLATINE | 0 | 0.1 | 182 | 182 | 0.0838 | 0.00038
PLATINE | +7.928 | +7.943 | 275 | TS1 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +7.809 | +7.824 | 275 | TS2 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +7.689 | +7.704 | 275 | TS3 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +7.570 | +7.585 | 275 | TS4 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +8.048 | +8.062 | 276 | TS10 | 2 | PLATINE | 0 | 0.1 | 135 | 135 | 0.0607 | 0.00027
PLATINE | +7.928 | +7.943 | 275 | TS6 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +7.809 | +7.824 | 275 | TS7 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +7.689 | +7.704 | 275 | TS8 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +7.570 | +7.585 | 275 | TS9 | 2 | PLATINE | 0 | 0.1 | 150 | 150 | 0.067 | 0.0003
PLATINE | +8.350 | +8.360 | 294 | M23 | 2 | PLATINE | 0.1 | 0.2 | 410 | 410 | 0.1762 | 0.00082
ECLISSE | +8.550 | +8.560 | E2 | E2 | 2 | ECLISSE | 0.1 | 0.2 | 410 | 410 | 0.1762 | 0.00082
ECLISSE | +4.990 | +5.000 | E2 | E2 | 2 | ECLISSE | 0.1 | 0.2 | 410 | 410 | 0.1762 | 0.00082
PLATINE | +8.350 | +8.360 | 287 | M32 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
PLATINE | +5.190 | +5.200 | 287 | M32 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
PLATINE | +8.350 | +8.360 | 287 | M22 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
PLATINE | +5.190 | +5.200 | 287 | M22 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
PLATINE | +5.190 | +5.200 | 294 | M23 | 2 | PLATINE | 0.1 | 0.2 | 410 | 410 | 0.1762 | 0.00082
PLATINE | +8.350 | +8.360 | 287 | M19 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
PLATINE | +5.190 | +5.200 | 287 | M19 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
PLATINE | +8.350 | +8.360 | 287 | M31 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
PLATINE | +5.190 | +5.200 | 287 | M31 | 2 | PLATINE | 0 | 0.1 | 200 | 200.003 | 0.0880013 | 0.000400006
COIFFE | +8.440 | +8.450 | 136 | PT3 | 2 | COIFFE | 0.1 | 0.2 | 484 | 484 | 0.20728 | 0.000968

# IfcBeam: PL10*240 (4)
In: Undefined
Description: PL10*240; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 277; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*240; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 240 mm; Largeur: 10 mm; Longueur: 150 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 277
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.0798 m2; NetVolume: 0.00036 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage
PLATINE | +7.928 | +7.943 | TS14
PLATINE | +7.809 | +7.824 | TS11
PLATINE | +7.689 | +7.704 | TS12
PLATINE | +7.570 | +7.585 | TS13

# IfcBeam: PL10*250, PRESCELLEMENT
In: Undefined
Description: PL10*250; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +3.200; Niveau haut: +3.430; Repère de pièce: 118; Repère d'assemblage: PS3; Phase: 1; Classe: 3; Matériau: S235-E24; Profil: PL10*250; Nom: PRESCELLEMENT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 250 mm; Largeur: 10 mm; Longueur: 230 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 118
BaseQuantities - Length: 230 mm; OuterSurfaceArea: 0.1246 m2; NetVolume: 0.000575 m3; NetWeight: 0 kg

# IfcBeam: PL10*260 (12)
In: Undefined
Description: PL10*260; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*260; Nom: SABOT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 260 mm; Largeur: 10 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x SABOT | +7.006 | +7.020 | 125 | S1 | 0.1 | 110 | 110.012 | 0.0646066 | 0.000286032
2 x SABOT | +7.000 | +7.565 | 120 | S1 | 0.4 | 565 | 565 | 0.3103 | 0.001469
SABOT | +7.107 | +7.117 | 117 | S5 | 0.1 | 170 | 170 | 0.097 | 0.000442
SABOT | +7.092 | +7.272 | 124 | S5 | 0.1 | 180 | 180.001 | 0.1024 | 0.000468002
SABOT | +7.069 | +7.079 | 116 | S4 | 0.1 | 170 | 170 | 0.097 | 0.000442
SABOT | +7.054 | +7.274 | 123 | S4 | 0.1 | 220 | 220.001 | 0.124 | 0.000572002
SABOT | +7.050 | +7.060 | 116 | S3 | 0.1 | 170 | 170 | 0.097 | 0.000442
SABOT | +7.035 | +7.275 | 122 | S3 | 0.1 | 240 | 240.001 | 0.1348 | 0.000624002
SABOT | +7.106 | +7.120 | 126 | S2 | 0.1 | 110 | 110.012 | 0.0646066 | 0.000286032
SABOT | +7.100 | +7.565 | 121 | S2 | 0.4 | 465 | 465 | 0.2563 | 0.001209

# IfcBeam: PL10*290 (2)
In: Undefined
Description: PL10*290; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.540; Niveau haut: +8.550; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*290; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface nette: 0.4 m2; Hauteur: 290 mm; Largeur: 10 mm; Longueur: 581 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - Length: 581 mm; OuterSurfaceArea: 0.3544 m2; NetVolume: 0.0016849 m3; NetWeight: 0 kg
Name | Repère de pièce = Reference | Repère d'assemblage
PLATINE | 274 | PT10
PLATINE | 108 | PT12

# IfcBeam: PL10*360 (4)
In: Undefined
Description: PL10*360; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +2.800; Niveau haut: +3.037; Repère de pièce: 499; Repère d'assemblage: G29; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: PL10*360; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 360 mm; Largeur: 10 mm; Longueur: 237.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 499
BaseQuantities - Length: 237.448 mm; OuterSurfaceArea: 0.115218 m2; NetVolume: 0.000519874 m3; NetWeight: 0 kg

# IfcBeam: PL10*370 (2)
In: Undefined
Description: PL10*370; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +4.121; Niveau haut: +4.430; Repère de pièce: 497; Repère d'assemblage: G28; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S235-E24; Profil: PL10*370; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 370 mm; Largeur: 10 mm; Longueur: 309.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 497
BaseQuantities - Length: 309.388 mm; OuterSurfaceArea: 0.14183 m2; NetVolume: 0.000653193 m3; NetWeight: 0 kg

# IfcBeam: PL10*420, PLATINE
In: Undefined
Description: PL10*420; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.550; Niveau haut: +8.560; Repère de pièce: 278; Repère d'assemblage: TS5; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: PL10*420; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface nette: 0.1 m2; Hauteur: 420 mm; Largeur: 10 mm; Longueur: 150 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 278
BaseQuantities - Length: 150 mm; OuterSurfaceArea: 0.1374 m2; NetVolume: 0.00063 m3; NetWeight: 0 kg

# IfcBeam: PL10*500, PLATINE
In: Undefined
Description: PL10*500; Material: Undefined/S235-E24
