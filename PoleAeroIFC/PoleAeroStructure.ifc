Properties of the parts of a building model (IFC2X3), part 3 of 5

# IfcBeam: TOLE6*109, GOUSSET
BaseQuantities - Length: 183.622 mm; OuterSurfaceArea: 0.0243077 m2; NetVolume: 0.0000645709 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*113, GOUSSET
In: Undefined
Description: TOLE6*113; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.692; Niveau haut: +7.804; Repère de pièce: 437; Repère d'assemblage: G8; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*113; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 112.8 mm; Largeur: 6 mm; Longueur: 168.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 437
BaseQuantities - Length: 168.223 mm; OuterSurfaceArea: 0.023904 m2; NetVolume: 0.0000636915 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*164 (8)
In: Undefined
Description: TOLE6*164; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: G18; Repère d'assemblage: G18; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*164; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 163.6 mm; Largeur: 6 mm; Longueur: 239.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G18
BaseQuantities - Length: 239.671 mm; OuterSurfaceArea: 0.0541094 m2; NetVolume: 0.000150545 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
4 x GOUSSET | +8.553 | +8.625
4 x GOUSSET | +10.337 | +10.408

# IfcBeam: TOLE6*167, GOUSSET
In: Undefined
Description: TOLE6*167; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.100; Niveau haut: +7.304; Repère de pièce: G5; Repère d'assemblage: G5; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*167; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 166.7 mm; Largeur: 6 mm; Longueur: 203.6 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G5
BaseQuantities - Length: 203.578 mm; OuterSurfaceArea: 0.0378729 m2; NetVolume: 0.000103242 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*171, GOUSSET
In: Undefined
Description: TOLE6*171; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.100; Niveau haut: +7.285; Repère de pièce: G6; Repère d'assemblage: G6; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*171; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 171.3 mm; Largeur: 6 mm; Longueur: 185.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G6
BaseQuantities - Length: 185.499 mm; OuterSurfaceArea: 0.0373877 m2; NetVolume: 0.000102049 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*175 (11)
In: Undefined
Description: TOLE6*175; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*175; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x GOUSSET | +7.365 | +7.380 | G20 | 0.1 | 174.7 | 308.8 | 308.793 | 0.0956274 | 0.000271289
GOUSSET | +7.836 | +7.852 | G20 | 0.1 | 174.7 | 308.8 | 308.795 | 0.0956287 | 0.000271292
2 x GOUSSET | +7.716 | +7.739 | G26 | 0.2 | 174.7 | 517.6 | 517.59 | 0.153031 | 0.000437792
2 x GOUSSET | +7.597 | +7.619 | G26 | 0.2 | 174.7 | 517.6 | 517.589 | 0.15303 | 0.00043779
2 x GOUSSET | +7.478 | +7.500 | G26 | 0.2 | 174.7 | 517.6 | 517.59 | 0.153031 | 0.000437792
GOUSSET | +7.836 | +7.852 | G20(?) | 0.1 | 174.7 | 308.8 | 308.795 | 0.0956287 | 0.000271292
GOUSSET | +7.100 | +7.265 | G7 | 0 | 175.1 | 165.1 | 165.14 | 0.0368183 | 0.000100577

# IfcBeam: TOLE6*178 (11)
In: Undefined
Description: TOLE6*178; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*178; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
2 x GOUSSET | +7.478 | +7.493 | G22 | 177.6 | 309.3 | 309.316 | 0.0970728 | 0.000275524
2 x GOUSSET | +7.365 | +7.380 | G22 | 177.6 | 309.3 | 309.316 | 0.0970728 | 0.000275524
3 x GOUSSET | +8.557 | +8.664 | G14 | 178.2 | 315.7 | 315.682 | 0.0777998 | 0.000218807
4 x GOUSSET | +11.113 | +11.219 | G14 | 178.2 | 315.7 | 315.682 | 0.0777998 | 0.000218807

# IfcBeam: TOLE6*182 (4)
In: Undefined
Description: TOLE6*182; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: G21; Repère d'assemblage: G21; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*182; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 181.7 mm; Largeur: 6 mm; Longueur: 304.7 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G21
BaseQuantities - Length: 304.744 mm; OuterSurfaceArea: 0.0973188 m2; NetVolume: 0.000276302 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
2 x GOUSSET | +7.478 | +7.493
2 x GOUSSET | +7.365 | +7.380

# IfcBeam: TOLE6*184, GOUSSET
In: Undefined
Description: TOLE6*184; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.562; Niveau haut: +8.714; Repère de pièce: G13; Repère d'assemblage: G13; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*184; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 184.1 mm; Largeur: 6 mm; Longueur: 316.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G13
BaseQuantities - Length: 316.283 mm; OuterSurfaceArea: 0.100503 m2; NetVolume: 0.000285511 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*190 (8)
In: Undefined
Description: TOLE6*190; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*190; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 190 mm; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | +7.445 | +7.465 | G4 | 0.1 | 448 | 448.047 | 0.149486 | 0.000427548
GOUSSET | +7.553 | +7.585 | G2 | 0.4 | 832.1 | 832.091 | 0.271252 | 0.000781094
GOUSSET | +7.672 | +7.704 | G2 | 0.4 | 832.1 | 832.091 | 0.271253 | 0.000781097
GOUSSET | +7.792 | +7.824 | G2 | 0.4 | 832.1 | 832.091 | 0.271253 | 0.000781097
GOUSSET | +7.792 | +7.824 | G1 | 0.4 | 832.1 | 832.091 | 0.270463 | 0.000778751
GOUSSET | +7.672 | +7.704 | G1 | 0.4 | 832.1 | 832.091 | 0.270463 | 0.000778751
GOUSSET | +7.553 | +7.585 | G1 | 0.4 | 832.1 | 832.091 | 0.270463 | 0.000778751
GOUSSET | +7.445 | +7.465 | G3 | 0.1 | 448 | 448.047 | 0.149088 | 0.000426367

# IfcBeam: TOLE6*196 (7)
In: Undefined
Description: TOLE6*196; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: G12; Repère d'assemblage: G12; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*196; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 195.7 mm; Largeur: 6 mm; Longueur: 296.9 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G12
BaseQuantities - OuterSurfaceArea: 0.0787037 m2; NetVolume: 0.000221956 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Length (mm)
3 x GOUSSET | +8.546 | +8.649 | 296.908
4 x GOUSSET | +11.894 | +11.997 | 296.906

# IfcBeam: TOLE6*197 (2)
In: Undefined
Description: TOLE6*197; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.906; Niveau haut: +7.918; Repère de pièce: G19; Repère d'assemblage: G19; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*197; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 196.8 mm; Largeur: 6 mm; Longueur: 200 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G19
BaseQuantities - Length: 200 mm; OuterSurfaceArea: 0.067384 m2; NetVolume: 0.000189468 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*219, GOUSSET
In: Undefined
Description: TOLE6*219; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.582; Niveau haut: +8.719; Repère de pièce: G15; Repère d'assemblage: G15; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*219; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 218.7 mm; Largeur: 6 mm; Longueur: 305.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G15
BaseQuantities - Length: 305.472 mm; OuterSurfaceArea: 0.107874 m2; NetVolume: 0.000307662 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*259 (5)
In: Undefined
Description: TOLE6*259; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*259; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | +7.419 | +7.439 | G24 | 0.4 | 258.8 | 560.1 | 560.056 | 0.254572 | 0.000737776
3 x GOUSSET | +10.143 | +10.400 | G16 | 0.2 | 258.6 | 541.4 | 541.372 | 0.207336 | 0.00059834
GOUSSET | +10.143 | +10.400 | G16 | 0.2 | 258.5 | 541.5 | 541.503 | 0.20733 | 0.00059832

# IfcBeam: TOLE6*261, GOUSSET
In: Undefined
Description: TOLE6*261; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.419; Niveau haut: +7.439; Repère de pièce: G25; Repère d'assemblage: G25; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*261; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 261.2 mm; Largeur: 6 mm; Longueur: 559.5 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G25
BaseQuantities - Length: 559.453 mm; OuterSurfaceArea: 0.258276 m2; NetVolume: 0.000748749 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*262 (4)
In: Undefined
Description: TOLE6*262; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: G23; Repère d'assemblage: G23; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*262; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 261.6 mm; Largeur: 6 mm; Longueur: 563.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G23
BaseQuantities - Length: 563.241 mm; OuterSurfaceArea: 0.260968 m2; NetVolume: 0.000756659 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
GOUSSET | +7.777 | +7.797
GOUSSET | +7.658 | +7.678
GOUSSET | +7.539 | +7.558
GOUSSET | +7.419 | +7.439

# IfcBeam: TOLE6*272 (4)
In: Undefined
Description: TOLE6*272; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +9.780; Niveau haut: +9.996; Repère de pièce: G17; Repère d'assemblage: G17; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*272; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.2 m2; Hauteur: 272.3 mm; Largeur: 6 mm; Longueur: 458.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G17
BaseQuantities - Length: 458.306 mm; OuterSurfaceArea: 0.188136 m2; NetVolume: 0.00054273 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*281 (4)
In: Undefined
Description: TOLE6*281; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +9.412; Niveau haut: +9.550; Repère de pièce: G27; Repère d'assemblage: G27; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*281; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 280.7 mm; Largeur: 6 mm; Longueur: 272.3 mm
Pset_BeamCommon - LoadBearing: yes; Reference: G27
BaseQuantities - Length: 272.302 mm; OuterSurfaceArea: 0.108188 m2; NetVolume: 0.000308615 m3; NetWeight: 0 kg

# IfcBeam: TOLE6*36 (3)
In: Undefined
Description: TOLE6*36; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: P2; Repère d'assemblage: P2; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*36; Nom: PLAQUETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 36 mm; Largeur: 6 mm; Longueur: 36 mm
Pset_BeamCommon - LoadBearing: yes; Reference: P2
BaseQuantities - Length: 36 mm; OuterSurfaceArea: 0.00269587 m2; NetVolume: 0.00000605613 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
PLAQUETTE | +7.347 | +7.383
PLAQUETTE | +7.413 | +7.449
PLAQUETTE | +7.480 | +7.516

# IfcBeam: TOLE6*60 (24)
In: Undefined
Description: TOLE6*60; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.985; Niveau haut: +8.045; Repère d'assemblage: S18; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE6*60; Nom: PLATINE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 6 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Reference | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
12 x PLATINE | 458 | 160 | 0.02184 | 0.0000576
12 x PLATINE | 457 | 260 | 0.03504 | 0.0000936

# IfcBeam: TOLE8*122, GOUSSET
In: Undefined
Description: TOLE8*122; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.097; Niveau haut: +8.350; Repère de pièce: 396; Repère d'assemblage: A21; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*122; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 122.3 mm; Largeur: 8 mm; Longueur: 279.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 396
BaseQuantities - Length: 279.372 mm; OuterSurfaceArea: 0.0590402 m2; NetVolume: 0.000213858 m3; NetWeight: 0 kg

# IfcBeam: TOLE8*126, GOUSSET
In: Undefined
Description: TOLE8*126; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.119; Niveau haut: +8.350; Repère de pièce: 390; Repère d'assemblage: A20; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*126; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 126.5 mm; Largeur: 8 mm; Longueur: 276.1 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 390
BaseQuantities - Length: 276.058 mm; OuterSurfaceArea: 0.0593226 m2; NetVolume: 0.000215043 m3; NetWeight: 0 kg

# IfcBeam: TOLE8*127 (4)
In: Undefined
Description: TOLE8*127; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 393; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*127; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 127.4 mm; Largeur: 8 mm; Longueur: 284.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 393
BaseQuantities - Length: 284.43 mm; NetVolume: 0.000226069 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage | OuterSurfaceArea (m2)
GOUSSET | +8.084 | +8.350 | M22 | 0.0622175
2 x GOUSSET | +5.200 | +5.466 | M23 | 0.0622174
GOUSSET | +8.084 | +8.350 | M19 | 0.0622174

# IfcBeam: TOLE8*133, GOUSSET
In: Undefined
Description: TOLE8*133; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +5.200; Niveau haut: +5.453; Repère de pièce: 395; Repère d'assemblage: M32; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*133; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 133 mm; Largeur: 8 mm; Longueur: 282.6 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 395
BaseQuantities - Length: 282.642 mm; OuterSurfaceArea: 0.0629307 m2; NetVolume: 0.000228977 m3; NetWeight: 0 kg

# IfcBeam: TOLE8*135 (8)
In: Undefined
Description: TOLE8*135; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.260; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*135; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Largeur: 8 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Hauteur (mm) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | +7.473 | 400 | M8 | 134.8 | 285.2 | 285.18 | 0.0635631 | 0.000231393
GOUSSET | +7.473 | 400 | M29 | 134.8 | 285.2 | 285.18 | 0.0635631 | 0.000231393
2 x GOUSSET | +7.473 | 400 | M27 | 134.8 | 285.2 | 285.18 | 0.0635631 | 0.000231393
GOUSSET | +7.510 | 397 | M4 | 134.5 | 282.5 | 282.487 | 0.0632325 | 0.000230162
2 x GOUSSET | +7.510 | 397 | M24 | 134.5 | 282.5 | 282.487 | 0.0632325 | 0.000230162
GOUSSET | +7.510 | 397 | M25 | 134.5 | 282.5 | 282.487 | 0.0632325 | 0.000230162

# IfcBeam: TOLE8*136 (2)
In: Undefined
Description: TOLE8*136; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 394; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*136; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 135.6 mm; Largeur: 8 mm; Longueur: 281.6 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 394
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | +8.106 | +8.350 | M32 | 281.584 | 0.0632132 | 0.000230114
GOUSSET | +5.200 | +5.444 | M22 | 281.588 | 0.0632128 | 0.000230112

# IfcBeam: TOLE8*137 (2)
In: Undefined
Description: TOLE8*137; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 392; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*137; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 136.5 mm; Largeur: 8 mm; Longueur: 283.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 392
BaseQuantities - NetVolume: 0.000230994 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère d'assemblage | Length (mm) | OuterSurfaceArea (m2)
GOUSSET | +5.200 | +5.423 | M19 | 283.412 | 0.0634448
GOUSSET | +8.127 | +8.350 | M31 | 283.409 | 0.063445

# IfcBeam: TOLE8*138 (12)
In: Undefined
Description: TOLE8*138; Material: Undefined/S235-E24
Tekla Commun - Matériau: S235-E24; Profil: TOLE8*138
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 138 mm; Largeur: 8 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Finition | Phase | Classe | Nom | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
7 x RAIDISSEUR CONSOLE | +8.175 | +8.475 | 515 | C9 | GALVA | 3 | 8 | RAIDISSEUR CONSOLE | 300 | 300 | 0.0677634 | 0.00024624
GOUSSET | +7.260 | +7.495 | 399 | M6 |  | 1 | 2 | GOUSSET | 280.9 | 280.893 | 0.0635542 | 0.000231438
GOUSSET | +7.260 | +7.495 | 399 | M28 |  | 1 | 2 | GOUSSET | 280.9 | 280.893 | 0.0635542 | 0.000231438
2 x GOUSSET | +7.260 | +7.495 | 399 | M26 |  | 1 | 2 | GOUSSET | 280.9 | 280.893 | 0.0635542 | 0.000231438
GOUSSET | +5.200 | +5.431 | 391 | M31 |  | 1 | 2 | GOUSSET | 280.4 | 280.41 | 0.0634576 | 0.00023106

# IfcBeam: TOLE8*140 (60)
In: Undefined
Description: TOLE8*140; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: 404; Repère d'assemblage: PN19; Phase: 1; Classe: 6; Matériau: S235-E24; Profil: TOLE8*140; Nom: RAIDISSEUR
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 140 mm; Largeur: 8 mm; Longueur: 320 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 404
BaseQuantities - Length: 320 mm; OuterSurfaceArea: 0.0591443 m2; NetVolume: 0.0002108 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
5 x RAIDISSEUR | +8.654 | +8.933
5 x RAIDISSEUR | +9.385 | +9.664
5 x RAIDISSEUR | +10.137 | +10.416
5 x RAIDISSEUR | +10.889 | +11.168
5 x RAIDISSEUR | +8.653 | +8.933
5 x RAIDISSEUR | +9.372 | +9.651
5 x RAIDISSEUR | +10.111 | +10.390
5 x RAIDISSEUR | +8.646 | +8.929
5 x RAIDISSEUR | +9.339 | +9.621
5 x RAIDISSEUR | +10.850 | +11.130
5 x RAIDISSEUR | +10.051 | +10.334
5 x RAIDISSEUR | +11.641 | +11.920

# IfcBeam: TOLE8*213 (4)
In: Undefined
Description: TOLE8*213; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +10.200; Niveau haut: +10.413; Repère de pièce: 402; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*213; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 213 mm; Largeur: 8 mm; Longueur: 253.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 402
BaseQuantities - NetWeight: 0 kg
Name | Repère d'assemblage | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | M7 | 253.171 | 0.0666447 | 0.000243523
GOUSSET | M8 | 253.165 | 0.0666437 | 0.00024352
GOUSSET | M34 | 253.162 | 0.0666432 | 0.000243518
GOUSSET | M29 | 253.162 | 0.0666432 | 0.000243518

# IfcBeam: TOLE8*235 (4)
In: Undefined
Description: TOLE8*235; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +10.991; Niveau haut: +11.226; Repère de pièce: 401; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*235; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 234.7 mm; Largeur: 8 mm; Longueur: 233.1 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 401
BaseQuantities - NetWeight: 0 kg
Name | Repère d'assemblage | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | M33 | 233.204 | 0.0672126 | 0.000245799
GOUSSET | M6 | 233.207 | 0.0672131 | 0.000245801
GOUSSET | M5 | 233.212 | 0.0672141 | 0.000245804
GOUSSET | M28 | 233.204 | 0.0672126 | 0.000245799

# IfcBeam: TOLE8*250 (4)
In: Undefined
Description: TOLE8*250; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +11.777; Niveau haut: +12.027; Repère de pièce: 398; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*250; Nom: GOUSSET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 249.8 mm; Largeur: 8 mm; Longueur: 215.1 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 398
BaseQuantities - NetWeight: 0 kg
Name | Repère d'assemblage | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
GOUSSET | M3 | 215.106 | 0.0673195 | 0.000246173
GOUSSET | M4 | 215.1 | 0.0673186 | 0.000246169
GOUSSET | M25 | 215.097 | 0.0673181 | 0.000246168
GOUSSET | M30 | 215.097 | 0.0673175 | 0.000246165

# IfcBeam: TOLE8*417, JARRET
In: Undefined
Description: TOLE8*417; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.338; Niveau haut: +7.768; Repère de pièce: 403; Repère d'assemblage: T3; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*417; Nom: JARRET
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.7 m2; Hauteur: 416.5 mm; Largeur: 8 mm; Longueur: 1465.4 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 403
BaseQuantities - Length: 1465.39 mm; OuterSurfaceArea: 0.681541 m2; NetVolume: 0.00262023 m3; NetWeight: 0 kg

# IfcBeam: TOLE8*60 (113)
In: Undefined
Description: TOLE8*60; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: P1; Repère d'assemblage: P1; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TOLE8*60; Nom: PLAQUETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 8 mm; Longueur: 60 mm
Pset_BeamCommon - LoadBearing: yes; Reference: P1
BaseQuantities - Length: 60 mm; OuterSurfaceArea: 0.00713225 m2; NetVolume: 0.0000225048 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
PLAQUETTE | +7.658 | +7.718
PLAQUETTE | +7.202 | +7.262
3 x PLAQUETTE | +6.745 | +6.805
PLAQUETTE | +6.288 | +6.348
PLAQUETTE | +5.832 | +5.892
PLAQUETTE | +7.665 | +7.725
PLAQUETTE | +7.205 | +7.265
PLAQUETTE | +6.285 | +6.345
PLAQUETTE | +5.825 | +5.885
2 x PLAQUETTE | +7.558 | +7.618
2 x PLAQUETTE | +7.016 | +7.076
2 x PLAQUETTE | +6.474 | +6.534
2 x PLAQUETTE | +5.932 | +5.992
PLAQUETTE | +5.744 | +5.804
PLAQUETTE | +6.144 | +6.204
PLAQUETTE | +6.545 | +6.605
PLAQUETTE | +6.945 | +7.005
PLAQUETTE | +7.346 | +7.406
PLAQUETTE | +7.746 | +7.806
PLAQUETTE | +5.816 | +5.876
PLAQUETTE | +6.281 | +6.341
PLAQUETTE | +7.209 | +7.269
4 x PLAQUETTE | +9.816 | +9.876
4 x PLAQUETTE | +9.412 | +9.472
4 x PLAQUETTE | +9.008 | +9.068
4 x PLAQUETTE | +8.605 | +8.665
4 x PLAQUETTE | +8.201 | +8.261
4 x PLAQUETTE | +7.797 | +7.857
4 x PLAQUETTE | +10.561 | +10.621
4 x PLAQUETTE | +10.112 | +10.172
4 x PLAQUETTE | +9.662 | +9.722
4 x PLAQUETTE | +9.213 | +9.273
4 x PLAQUETTE | +8.764 | +8.824
4 x PLAQUETTE | +8.314 | +8.374
4 x PLAQUETTE | +7.865 | +7.925
4 x PLAQUETTE | +11.311 | +11.371
4 x PLAQUETTE | +10.826 | +10.886
4 x PLAQUETTE | +10.341 | +10.401
4 x PLAQUETTE | +9.856 | +9.916
4 x PLAQUETTE | +9.371 | +9.431
4 x PLAQUETTE | +8.886 | +8.946
4 x PLAQUETTE | +8.401 | +8.461
4 x PLAQUETTE | +7.916 | +7.976
PLAQUETTE | +7.674 | +7.734

# IfcBeam: TUBE-21.3*2 (17)
In: Undefined
Description: TUBE-21.3*2; Material: Undefined/S235-E24
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 4; Matériau: S235-E24; Profil: TUBE-21.3*2; Nom: LISSE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 21.3 mm; Largeur: 21.3 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
LISSE | +9.233 | +9.254 | 626(?) | GC0(?) | 0.2 | 3710 | 3709.99 | 0.245559 | 0.000429617
2 x LISSE | +8.643 | +8.664 | 623(?) | GC0(?) | 0 | 223.5 | 223.498 | 0.0146653 | 0.0000254403
LISSE | +9.233 | +9.254 | 628 | GC12 | 0.1 | 995 | 995.01 | 0.0659518 | 0.000115222
LISSE | +8.643 | +8.664 | 623 | GC12 | 0.1 | 1828.7 | 1828.67 | 0.120603 | 0.000210873
LISSE | +9.233 | +9.254 | 627 | GC8 | 0.2 | 2460 | 2460.01 | 0.162868 | 0.000284869
LISSE | +9.233 | +9.254 | 626 | GC10 | 0.4 | 5190 | 5190 | 0.343468 | 0.000601002
LISSE | +8.643 | +8.664 | 623 | GC8 | 0.1 | 1828.7 | 1828.67 | 0.120603 | 0.000210873
LISSE | +9.233 | +9.254 | 622 | GC4 | 0.2 | 3625 | 3624.99 | 0.239936 | 0.000419774
2 x LISSE | +9.428 | +9.449 | 619 | GC2 | 0 | 660 | 659.996 | 0.0437893 | 0.0000764275
LISSE | +9.233 | +9.254 | 621 | GC6 | 0.1 | 970 | 969.994 | 0.0642969 | 0.000112325
LISSE | +9.428 | +9.449 | 619 | GC3 | 0 | 660 | 660 | 0.0437895 | 0.000076428
LISSE | +9.428 | +9.449 | 619 | GC1 | 0 | 660 | 659.996 | 0.0437893 | 0.0000764275
LISSE | +9.428 | +9.449 | 619 | GC3 | 0 | 660 | 659.996 | 0.0437893 | 0.0000764275
LISSE | +9.233 | +9.254 | 621 | GC7 | 0.1 | 970 | 969.994 | 0.0642969 | 0.000112325
LISSE | +9.428 | +9.449 | 619 | GC3 | 0 | 660 | 659.996 | 0.0437893 | 0.0000764276

# IfcBeam: TUBE-26.9*2 (12)
In: Undefined
Description: TUBE-26.9*2; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.660; Niveau haut: +8.687; Phase: 1; Classe: 5; Matériau: S235-E24; Profil: TUBE-26.9*2; Nom: LISSE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.4 m2; Hauteur: 26.9 mm; Largeur: 26.9 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Reference | Repère d'assemblage | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
LISSE | 487 | MC3 | 3845 | 0.321399 | 0.000574443
6 x LISSE | 486 | MC1 | 3690 | 0.308449 | 0.000551286
3 x LISSE | 487 | MC3 | 3845 | 0.321399 | 0.000574444
2 x LISSE | 487 | MC2 | 3845 | 0.321399 | 0.000574442

# IfcBeam: TUBE-C-100*100*4 (64)
In: Undefined
Description: TUBE-C-100*100*4; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Matériau: S235-E24; Profil: TUBE-C-100*100*4
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 100 mm; Largeur: 100 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Classe | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
LISSE CHASSIS | +2.760 | +2.860 | 178 | L29 | 3 | LISSE CHASSIS | 0.3 | 1.2 | 3025 | 1.16765 | 0.0046464
MONTANT | +2.865 | +4.445 | M35 | M35 | 2 | MONTANT | 0 | 0.7 | 1580 | 0.60988 | 0.00242688
LISSE ACROTERE | +10.195 | +10.295 | L16 | L16 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7665 | 2.95869 | 0.0117734
3 x LISSE ACROTERE | +8.450 | +8.550 | L44 | L44 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7755 | 2.99343 | 0.0119117
LISSE ACROTERE | +11.020 | +11.120 | L16 | L16 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7665 | 2.95869 | 0.0117734
LISSE ACROTERE | +11.820 | +11.920 | L16 | L16 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7665 | 2.95869 | 0.0117734
LISSE ACROTERE | +8.450 | +8.550 | L47 | L47 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7755 | 2.99343 | 0.0119117
LISSE ACROTERE | +8.450 | +8.550 | L46 | L46 | 2 | LISSE ACROTERE | 0.8 | 3.3 | 8185 | 3.15941 | 0.0125722
LISSE ACROTERE | +8.450 | +8.550 | L49 | L49 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7775 | 3.00115 | 0.0119424
LISSE CHASSIS | +4.450 | +4.550 | L60 | L60 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3495 | 1.34907 | 0.00536832
2 x LISSE CHASSIS | +4.450 | +4.550 | L19 | L19 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3650 | 1.4089 | 0.0056064
LISSE CHASSIS | +4.450 | +4.550 | L61 | L61 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3405 | 1.31433 | 0.00523008
LISSE ACROTERE | +10.195 | +10.295 | L17 | L17 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7665 | 2.95869 | 0.0117734
LISSE ACROTERE | +11.020 | +11.120 | L17 | L17 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7665 | 2.95869 | 0.0117734
LISSE ACROTERE | +11.820 | +11.920 | L17 | L17 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7665 | 2.95869 | 0.0117734
LISSE CHASSIS | +4.940 | +5.040 | L62 | L62 | 2 | LISSE CHASSIS | 0.5 | 2.1 | 5140 | 1.98404 | 0.00789504
LISSE CHASSIS | +2.800 | +2.900 | L30 | L30 | 3 | LISSE CHASSIS | 0.2 | 0.7 | 2005 | 0.773931 | 0.00307968
LISSE CHASSIS | +1.000 | +1.100 | 107 | L25 | 2 | LISSE CHASSIS | 0.5 | 2.1 | 5140 | 1.98404 | 0.00789504
LISSE CHASSIS | +7.100 | +7.200 | L59 | L59 | 2 | LISSE CHASSIS | 0.5 | 1.9 | 4990 | 1.92614 | 0.00766464
LISSE CHASSIS | +4.900 | +5.000 | 259 | L58 | 2 | LISSE CHASSIS | 0.5 | 1.9 | 4990 | 1.92614 | 0.00766464
LISSE CHASSIS | +2.800 | +2.900 | L57 | L57 | 2 | LISSE CHASSIS | 0.5 | 1.9 | 4990 | 1.92614 | 0.00766464
LISSE CHASSIS | +1.000 | +1.100 | 106 | L24 | 2 | LISSE CHASSIS | 0.5 | 1.9 | 4990 | 1.92614 | 0.00766464
LISSE CHASSIS | +7.100 | +7.200 | L56 | L56 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 4090 | 1.57874 | 0.00628224
LISSE CHASSIS | +4.900 | +5.000 | 256 | L55 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 4090 | 1.57874 | 0.00628224
LISSE CHASSIS | +4.940 | +5.040 | L54 | L54 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3790 | 1.46294 | 0.00582144
LISSE CHASSIS | +2.760 | +2.860 | 105 | L23 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3790 | 1.46294 | 0.00582144
LISSE CHASSIS | +2.800 | +2.900 | L22 | L22 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 4090 | 1.57874 | 0.00628224
LISSE CHASSIS | +1.000 | +1.100 | 104 | L2 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 4090 | 1.57874 | 0.00628224
LISSE CHASSIS | +7.100 | +7.200 | L53 | L53 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 3980 | 1.53628 | 0.00611328
LISSE CHASSIS | +4.900 | +5.000 | 253 | L52 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 3980 | 1.53628 | 0.00611328
LISSE CHASSIS | +2.800 | +2.900 | L51 | L51 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 3980 | 1.53628 | 0.00611328
LISSE CHASSIS | +1.000 | +1.100 | 103 | L21 | 2 | LISSE CHASSIS | 0.3 | 1.6 | 3980 | 1.53628 | 0.00611328
2 x LISSE CHASSIS | +7.100 | +7.200 | L19 | L19 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3650 | 1.4089 | 0.0056064
LISSE CHASSIS | +7.100 | +7.200 | L50 | L50 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3495 | 1.34907 | 0.00536832
LISSE CHASSIS | +2.760 | +2.860 | 102 | L20 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3495 | 1.34907 | 0.00536832
2 x LISSE CHASSIS | +2.760 | +2.860 | 101 | L4 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3650 | 1.4089 | 0.0056064
MONTANT | +4.555 | +7.095 | M9 | M9 | 2 | MONTANT | 0 | 1 | 2540 | 0.98044 | 0.00390144
LISSE CHASSIS | +7.100 | +7.200 | L61 | L61 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3405 | 1.31433 | 0.00523008
LISSE CHASSIS | +2.760 | +2.860 | 100 | L18 | 2 | LISSE CHASSIS | 0.3 | 1.5 | 3405 | 1.31433 | 0.00523008
MONTANT | -0.095 | +2.755 | M16 | M16 | 2 | MONTANT | 0 | 1.1 | 2850 | 1.1001 | 0.0043776
LISSE ACROTERE | +8.450 | +8.550 | L16 | L16 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7665 | 2.95869 | 0.0117734
LISSE ACROTERE | +8.450 | +8.550 | L15 | L15 | 2 | LISSE ACROTERE | 0.8 | 3 | 7485 | 2.88921 | 0.011497
LISSE ACROTERE | +8.450 | +8.550 | L48 | L48 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7775 | 3.00115 | 0.0119424
LISSE ACROTERE | +8.450 | +8.550 | L14 | L14 | 2 | LISSE ACROTERE | 1.1 | 4.1 | 10525 | 4.06265 | 0.0161664
3 x LISSE ACROTERE | +8.450 | +8.550 | L12 | L12 | 2 | LISSE ACROTERE | 0.3 | 1.5 | 3660 | 1.41276 | 0.00562176
LISSE ACROTERE | +8.450 | +8.550 | L45 | L45 | 2 | LISSE ACROTERE | 0.3 | 1.5 | 3660 | 1.41276 | 0.00562176
4 x LISSE ACROTERE | +8.450 | +8.550 | L64 | L64 | 2 | LISSE ACROTERE | 0.3 | 1.5 | 3660 | 1.41276 | 0.00562176
LISSE ACROTERE | +8.450 | +8.550 | L13 | L13 | 2 | LISSE ACROTERE | 0.3 | 1.5 | 3660 | 1.41276 | 0.00562176
LISSE ACROTERE | +8.450 | +8.550 | L11 | L11 | 2 | LISSE ACROTERE | 0.3 | 1.5 | 3610 | 1.39346 | 0.00554496
LISSE ACROTERE | +8.450 | +8.550 | L10 | L10 | 2 | LISSE ACROTERE | 0.3 | 1.5 | 3660 | 1.41276 | 0.00562176
LISSE ACROTERE | +8.450 | +8.550 | L9 | L9 | 2 | LISSE ACROTERE | 0.3 | 1.5 | 3620 | 1.39732 | 0.00556032
LISSE ACROTERE | +8.450 | +8.550 | L8 | L8 | 2 | LISSE ACROTERE | 0.8 | 3 | 7475 | 2.88535 | 0.0114816
LISSE ACROTERE | +8.450 | +8.550 | L7 | L7 | 2 | LISSE ACROTERE | 0.3 | 1.7 | 4245 | 1.63857 | 0.00652032
LISSE ACROTERE | +8.450 | +8.550 | L6 | L6 | 2 | LISSE ACROTERE | 0.8 | 3.1 | 7755 | 2.99343 | 0.0119117

# IfcBeam: TUBE-C-100*100*5 (7)
In: Undefined
Description: TUBE-C-100*100*5; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.340; Niveau haut: +8.440; Repère de pièce: 568; Repère d'assemblage: C9; Finition: GALVA; Phase: 3; Classe: 8; Matériau: S235-E24; Profil: TUBE-C-100*100*5; Nom: CONSOLE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.2 m2; Surface nette: 0.7 m2; Hauteur: 100 mm; Largeur: 100 mm; Longueur: 1518 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 568
BaseQuantities - Length: 1517.99 mm; OuterSurfaceArea: 0.581392 m2; NetVolume: 0.00287315 m3; NetWeight: 0 kg

# IfcBeam: TUBE-C-120*120*4, BUTON
In: Undefined
Description: TUBE-C-120*120*4; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.532; Niveau haut: +7.652; Repère de pièce: 81; Repère d'assemblage: B5; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TUBE-C-120*120*4; Nom: BUTON
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.5 m2; Surface nette: 2.1 m2; Hauteur: 120 mm; Largeur: 120 mm; Longueur: 4456.2 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 81
BaseQuantities - Length: 4456.15 mm; OuterSurfaceArea: 2.07657 m2; NetVolume: 0.00795302 m3; NetWeight: 0 kg

# IfcBeam: TUBE-C-40*40*4 (8)
In: Undefined
Description: TUBE-C-40*40*4; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: B13; Repère d'assemblage: B13; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TUBE-C-40*40*4; Nom: BUTON
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.7 m2; Hauteur: 40 mm; Largeur: 40 mm; Longueur: 3700 mm
Pset_BeamCommon - LoadBearing: yes; Reference: B13
BaseQuantities - Length: 3700 mm; OuterSurfaceArea: 0.5402 m2; NetVolume: 0.0021312 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
4 x BUTON | +9.882 | +9.936
4 x BUTON | +10.265 | +10.319

# IfcBeam: TUBE-C-60*60*3 (12)
In: Undefined
Description: TUBE-C-60*60*3; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.985; Niveau haut: +8.045; Repère de pièce: 205; Repère d'assemblage: S18; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TUBE-C-60*60*3; Nom: SOLIVE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.1 m2; Surface nette: 0.4 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 1182 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 205
BaseQuantities - NetWeight: 0 kg
Name | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
11 x SOLIVE | 1182 | 0.270678 | 0.000808488
SOLIVE | 1181.99 | 0.270676 | 0.000808482

# IfcBeam: TUBE-C-80*80*4 (3)
In: Undefined
Description: TUBE-C-80*80*4; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: TUBE-C-80*80*4
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 80 mm; Largeur: 80 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
LISSE ACROTERE | +8.470 | +8.550 | L1 | LISSE ACROTERE | 0.3 | 1.2 | 4110 | 4110 | 1.25766 | 0.00499776
RAMASSE PANNE | +7.289 | +7.611 | RP2 | RAMASSE PANNE | 0 | 2.5 | 7691.3 | 7691.31 | 2.35354 | 0.00934957
RAMASSE PANNE | +7.531 | +7.856 | RP1 | RAMASSE PANNE | 0 | 2.5 | 7781.4 | 7781.35 | 2.38109 | 0.00945907

# IfcBeam: UPF-100*50*4 (32)
In: Undefined
Description: UPF-100*50*4; Material: Undefined/S235-E24
Tekla Commun - Matériau: S235-E24; Profil: UPF-100*50*4
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 100 mm; Largeur: 50 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Phase | Classe | Nom | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
SUPPORT | +5.450 | +5.500 | S44 | 1 | 3 | SUPPORT | 0.1 | 3.2 | 8055 | 8055 | 3.1591 | 0.00618624
SUPPORT | +5.450 | +5.500 | S43 | 1 | 3 | SUPPORT | 0.1 | 3.7 | 9515 | 9515 | 3.73142 | 0.00730752
2 x LISSE CONTREBARDAGE | +8.023 | +8.197 | L71 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.6 | 3959.8 | 3959.78 | 1.55334 | 0.00304024
3 x LISSE CONTREBARDAGE | +8.147 | +8.316 | L67 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3791.9 | 3791.88 | 1.48795 | 0.00291216
3 x LISSE CONTREBARDAGE | +8.267 | +8.438 | L66 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3864.8 | 3864.84 | 1.51655 | 0.00296819
2 x LISSE CONTREBARDAGE | +8.030 | +8.195 | L65 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3673.4 | 3673.38 | 1.44089 | 0.00281995
4 x LISSE CONTREBARDAGE | +8.149 | +8.314 | L65 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3673.4 | 3673.38 | 1.44089 | 0.00281995
3 x LISSE CONTREBARDAGE | +8.268 | +8.429 | L26 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3534.8 | 3534.82 | 1.38657 | 0.00271353
LISSE CONTREBARDAGE | +8.029 | +8.195 | L70 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3693.4 | 3693.39 | 1.44873 | 0.00283532
LISSE CONTREBARDAGE | +8.149 | +8.315 | L70 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3693.4 | 3693.39 | 1.44873 | 0.00283532
LISSE CONTREBARDAGE | +8.268 | +8.429 | L69 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3544.8 | 3544.82 | 1.39049 | 0.00272122
BAIONNETTE | +7.690 | +8.445 | B16 | 1 | 2 | BAIONNETTE | 0 | 0.4 | 755 | 754.999 | 0.275055 | 0.000534959
BAIONNETTE | +7.775 | +8.445 | B11 | 1 | 2 | BAIONNETTE | 0 | 0.2 | 670 | 669.999 | 0.241735 | 0.000469679
BAIONNETTE | +7.655 | +8.445 | B9 | 1 | 2 | BAIONNETTE | 0 | 0.4 | 790 | 789.999 | 0.288775 | 0.000561839
BAIONNETTE | +7.535 | +8.445 | B7 | 1 | 2 | BAIONNETTE | 0 | 0.4 | 910 | 909.999 | 0.335815 | 0.000653999
LISSE | +1.440 | +1.490 | L31 | 2 | 2 | LISSE | 0.3 | 1.2 | 3000 | 3000 | 1.17754 | 0.002304 | Tekla Commun - Finition: GALVA
LISSE | +0.100 | +0.150 | L31 | 2 | 2 | LISSE | 0.3 | 1.2 | 3000 | 3000 | 1.17754 | 0.002304 | Tekla Commun - Finition: GALVA
LISSE CONTREBARDAGE | +8.023 | +8.195 | L68 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3898.7 | 3898.68 | 1.52916 | 0.00299289
LISSE CONTREBARDAGE | +8.268 | +8.429 | L26 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3534.8 | 3534.81 | 1.38657 | 0.00271353
LISSE CONTREBARDAGE | +8.023 | +8.197 | L28 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.6 | 3959.8 | 3959.78 | 1.55334 | 0.00304024
LISSE CONTREBARDAGE | +8.022 | +8.195 | L27 | 1 | 2 | LISSE CONTREBARDAGE | 0 | 1.5 | 3898.5 | 3898.5 | 1.52913 | 0.00299284

# IfcBeam: UPF-150*70*5 (6)
In: Undefined
Description: UPF-150*70*5; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.950; Niveau haut: +8.100; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: UPF-150*70*5; Nom: LONGERON
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0.5 m2; Hauteur: 150 mm; Largeur: 70 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
3 x LONGERON | L72 | 4.4 | 7755 | 4.42315 | 0.010857
LONGERON | L36 | 4.1 | 7265 | 4.14385 | 0.010171
LONGERON | L35 | 4.3 | 7490 | 4.2721 | 0.010486
LONGERON | L34 | 4.3 | 7575 | 4.32055 | 0.010605

# IfcBeam: UPF-200*80*4 (14)
In: Undefined
Description: UPF-200*80*4; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.460; Niveau haut: +7.540; Repère de pièce: 578; Finition: GALVA; Phase: 3; Classe: 8; Matériau: S235-E24; Profil: UPF-200*80*4; Nom: COLLERETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 200 mm; Largeur: 80 mm; Longueur: 192 mm
Pset_BeamCommon - LoadBearing: yes; Reference: 578
BaseQuantities - Length: 192 mm; OuterSurfaceArea: 0.120734 m2; NetVolume: 0.000229532 m3; NetWeight: 0 kg
Name | Repère d'assemblage
6 x COLLERETTE | P4
8 x COLLERETTE | P3

# IfcBeam: UPN200 (2)
In: Undefined
Description: UPN200; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: +5.155; Niveau haut: +5.230; Phase: 1; Classe: 3; Matériau: S275-E28; Profil: UPN200; Nom: SUPPORT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 200 mm; Largeur: 75 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Repère de pièce = Repère d'assemblage = Reference | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
SUPPORT | S47 | 1.6 | 5.4 | 8055 | 5.3163 | 0.0256494
SUPPORT | S48 | 1.9 | 6.4 | 9515 | 6.2799 | 0.0302984

# IfcBeam: UPN260 (20)
In: Undefined
Description: UPN260; Material: Undefined/S275-E28
Tekla Commun - Finition: GALVA; Phase: 3; Classe: 2; Matériau: S275-E28; Profil: UPN260; Nom: LIMON
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Hauteur: 260 mm; Largeur: 90 mm
Pset_BeamCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface supérieure totale (m2) | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
3 x LIMON | +8.650 | +8.910 | 606 | L90 | 0.1 | 0.7 | 873.9 | 873.889 | 0.727075 | 0.00382783
LIMON | +8.650 | +8.910 | 605 | L89 | 0.1 | 0.7 | 873.9 | 873.889 | 0.727076 | 0.00382783
LIMON | +8.650 | +8.910 | 605 | L89 | 0.1 | 0.7 | 873.9 | 873.889 | 0.727075 | 0.00382783
LIMON | +8.440 | +8.700 | 604(?) | L33(?) | 0.1 | 1 | 1246 | 1246.01 | 1.03668 | 0.00572907
LIMON | +8.440 | +8.700 | 603 | L63 | 0.1 | 1 | 1246 | 1246.01 | 1.03668 | 0.00572907
LIMON | +7.850 | +8.110 | 534 | L63 | 0.2 | 1.6 | 1911.9 | 1911.89 | 1.59069 | 0.00868451
LIMON | +8.650 | +8.910 | 605 | L89 | 0.1 | 0.7 | 873.9 | 873.893 | 0.727079 | 0.00382784
LIMON | +8.440 | +8.700 | L91 | L91 | 0.1 | 0.7 | 990 | 989.993 | 0.823674 | 0.00472821
LIMON | +7.850 | +8.110 | 533(?) | L33(?) | 0.2 | 1.6 | 1911.9 | 1911.89 | 1.59069 | 0.00868451
2 x LIMON | +8.440 | +8.700 | L92(?) | L92(?) | 0.3 | 3.8 | 4500 | 4500 | 3.744 | 0.021492
LIMON | +7.850 | +8.110 | 534(?) | L75(?) | 0.2 | 1.6 | 1911.9 | 1911.89 | 1.59069 | 0.00868451
LIMON | +7.850 | +8.110 | 533(?) | L5(?) | 0.2 | 1.6 | 1911.9 | 1911.89 | 1.59069 | 0.00868451
LIMON | +8.440 | +8.700 | L88 | L88 | 0.1 | 0.7 | 990 | 989.993 | 0.823674 | 0.00472821
LIMON | +8.440 | +8.700 | L87(?) | L87(?) | 0.3 | 2.5 | 2890 | 2890.01 | 2.40449 | 0.0138027
LIMON | +8.440 | +8.700 | 554(?) | L5(?) | 0.3 | 2.5 | 2851 | 2851.01 | 2.37204 | 0.0133945
LIMON | +8.440 | +8.700 | L93 | L93 | 0.3 | 2.5 | 2890 | 2890.01 | 2.40449 | 0.0138027
LIMON | +8.440 | +8.700 | 553(?) | L75(?) | 0.3 | 2.5 | 2851 | 2851.01 | 2.37204 | 0.0133945

# IfcColumn: HEA100 (6)
In: Undefined
Description: HEA100; Material: Undefined/S275-E28
Tekla Commun - Niveau haut: +8.445; Classe: 2; Matériau: S275-E28; Profil: HEA100; Nom: BAIONNETTE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 96 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Repère de pièce = Reference | Repère d'assemblage | Phase | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
BAIONNETTE | +8.053 | 211 | PT5 | 4 | 0.2 | 392.4 | 392.36 | 0.220114 | 0.000781703
BAIONNETTE | +7.100 | B3 | B3 | 1 | 0.7 | 1345 | 1345 | 0.754545 | 0.00269
BAIONNETTE | +7.100 | B2 | B2 | 1 | 0.7 | 1345 | 1345 | 0.754545 | 0.00269
BAIONNETTE | +7.100 | B1 | B1 | 1 | 0.7 | 1345 | 1345 | 0.754544 | 0.00268999
BAIONNETTE | +8.053 | 38 | PT4 | 1 | 0.2 | 392.4 | 392.36 | 0.220114 | 0.000781703
BAIONNETTE | +8.053 | 211 | PT6 | 1 | 0.2 | 392.4 | 392.36 | 0.220114 | 0.000781703

# IfcColumn: HEA140 (16)
In: Undefined
Description: HEA140; Material: Undefined/S275-E28
Tekla Commun - Phase: 1; Classe: 2; Matériau: S275-E28; Profil: HEA140; Nom: MONTANT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 133 mm; Largeur: 140 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MONTANT | +7.260 | +10.980 | 238 | M34 | 3 | 3719.7 | 3719.7 | 2.95344 | 0.0111274
MONTANT | +7.260 | +11.800 | 237 | M33 | 3.7 | 4540.1 | 4540.15 | 3.60488 | 0.0135982
MONTANT | +7.260 | +12.603 | 225 | M30 | 4.3 | 5342.5 | 5342.55 | 4.24198 | 0.0160188
MONTANT | +7.260 | +10.980 | 224 | M29 | 3 | 3719.7 | 3719.7 | 2.95344 | 0.0111274
MONTANT | +7.260 | +11.800 | 223 | M28 | 3.7 | 4540.1 | 4540.15 | 3.60488 | 0.0135982
MONTANT | +7.260 | +12.603 | 206 | M25 | 4.3 | 5342.5 | 5342.55 | 4.24198 | 0.0160188
MONTANT | +7.260 | +10.980 | 217 | M27 | 3 | 3719.7 | 3719.7 | 2.95344 | 0.0111274
MONTANT | +7.260 | +11.800 | 212 | M26 | 3.7 | 4540.1 | 4540.15 | 3.60488 | 0.0135982
MONTANT | +7.260 | +12.603 | 204 | M24 | 4.3 | 5342.5 | 5342.55 | 4.24198 | 0.0160188
MONTANT | +8.058 | +8.550 | 49 | M36 | 0.4 | 492.2 | 492.193 | 0.390801 | 0.0014788
MONTANT | +7.260 | +10.980 | 48 | M8 | 3 | 3719.7 | 3719.7 | 2.95344 | 0.0111274
MONTANT | +8.460 | +10.980 | 47 | M7 | 1.9 | 2519.7 | 2519.7 | 2.00064 | 0.00750577
MONTANT | +7.260 | +11.800 | 46 | M6 | 3.7 | 4540.1 | 4540.15 | 3.60488 | 0.0135982
MONTANT | +8.560 | +11.800 | 45 | M5 | 2.6 | 3240.1 | 3240.15 | 2.57268 | 0.00967476
MONTANT | +7.260 | +12.603 | 44 | M4 | 4.3 | 5342.5 | 5342.55 | 4.24198 | 0.0160188
MONTANT | +8.560 | +12.603 | 43 | M3 | 3.3 | 4042.5 | 4042.55 | 3.20978 | 0.0120954

# IfcColumn: HEA200 (7)
In: Undefined
Description: HEA200; Material: Undefined/S275-E28
Tekla Commun - Niveau haut: +8.350; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: HEA200; Nom: MONTANT
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 190 mm; Largeur: 200 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MONTANT | +7.940 | 233 | M20 | 0.4 | 410 | 409.994 | 0.465754 | 0.00209302
MONTANT | +5.200 | 581 | M32 | 3.7 | 3150 | 3149.99 | 3.57839 | 0.0160807
MONTANT | +5.200 | 158 | M23 | 3.7 | 3150 | 3150 | 3.5784 | 0.0160807
MONTANT | +7.940 | 233 | M20 | 0.4 | 410 | 409.995 | 0.465755 | 0.00209303
MONTANT | +5.200 | 157 | M22 | 3.7 | 3150 | 3149.99 | 3.57839 | 0.0160807
MONTANT | +5.200 | 156 | M19 | 3.7 | 3150 | 3149.99 | 3.57839 | 0.0160807
MONTANT | +5.200 | 232 | M31 | 3.7 | 3150 | 3149.99 | 3.57839 | 0.0160807

# IfcColumn: IPE160 (2)
In: Undefined
Description: IPE160; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: -0.190; Niveau haut: +2.672; Finition: GALVA; Phase: 2; Classe: 2; Matériau: S275-E28; Profil: IPE160; Nom: POTEAU
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 1.7 m2; Hauteur: 160 mm; Largeur: 82 mm; Longueur: 2862 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 2861.96 mm; OuterSurfaceArea: 1.783 m2; NetVolume: 0.00554292 m3; NetWeight: 0 kg
Name | Repère de pièce = Reference | Repère d'assemblage
POTEAU | 131 | PT13
POTEAU | 194 | PT11

# IfcColumn: IPE200 (9)
In: Undefined
Description: IPE200; Material: Undefined/S275-E28
Tekla Commun - Niveau haut: +8.550; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE200; Nom: TRAVERSE SHED
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 200 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
TRAVERSE SHED | +8.058 | 71 | TS10 | 0.4 | 491.6 | 491.565 | 0.377522 | 0.00116547
TRAVERSE SHED | +7.581 | 70 | TS9 | 0.7 | 969.2 | 969.246 | 0.744381 | 0.00246705
TRAVERSE SHED | +7.700 | 69 | TS8 | 0.7 | 849.8 | 849.825 | 0.652666 | 0.00214166
TRAVERSE SHED | +7.820 | 68 | TS7 | 0.4 | 730.4 | 730.405 | 0.560951 | 0.00181626
TRAVERSE SHED | +7.939 | 67 | TS6 | 0.4 | 611 | 610.985 | 0.469236 | 0.00149087
TRAVERSE SHED | +7.581 | 64 | TS4 | 0.7 | 969.2 | 969.246 | 0.744381 | 0.00247103
TRAVERSE SHED | +7.700 | 63 | TS3 | 0.7 | 849.8 | 849.825 | 0.652666 | 0.00214563
TRAVERSE SHED | +7.820 | 62 | TS2 | 0.4 | 730.4 | 730.405 | 0.560951 | 0.00182023
TRAVERSE SHED | +7.939 | 61 | TS1 | 0.4 | 611 | 610.985 | 0.469236 | 0.00149484

# IfcColumn: IPE240 (4)
In: Undefined
Description: IPE240; Material: Undefined/S275-E28
Tekla Commun - Niveau haut: +8.550; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE240; Nom: TRAVERSE SHED
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 240 mm; Largeur: 120 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
TRAVERSE SHED | +7.939 | 76 | TS14 | 0.4 | 611.3 | 611.299 | 0.563618 | 0.00199593
TRAVERSE SHED | +7.580 | 75 | TS13 | 1 | 969.6 | 969.56 | 0.893934 | 0.00332812
TRAVERSE SHED | +7.700 | 74 | TS12 | 0.7 | 850.1 | 850.14 | 0.783829 | 0.00288406
TRAVERSE SHED | +7.819 | 73 | TS11 | 0.7 | 730.7 | 730.719 | 0.673723 | 0.00243999

# IfcColumn: IPE270 (3)
In: Undefined
Description: IPE270; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: -0.180; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE270; Nom: POTEAU
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Hauteur: 270 mm; Largeur: 135 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
POTEAU | +7.925 | PT9 | 8.7 | 8105 | 8.4373 | 0.035673
POTEAU | +7.805 | PT8 | 8.5 | 7985 | 8.31239 | 0.0351449
POTEAU | +7.685 | PT7 | 8.5 | 7865 | 8.18747 | 0.0346167

# IfcColumn: IPE400 (2)
In: Undefined
Description: IPE400; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: -0.180; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE400; Nom: POTEAU
Tekla Quantités - Poids: 0 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Hauteur: 400 mm; Largeur: 180 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Surface nette (m2) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
POTEAU | +7.370 | 2 | PT2 | 11.4 | 7550 | 11.0759 | 0.0609119
POTEAU | +7.840 | PT1 | PT1 | 12.1 | 8020 | 11.7653 | 0.0647037

# IfcColumn: IPE500 (4)
In: Undefined
Description: IPE500; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: -0.185; Classe: 2; Matériau: S275-E28; Profil: IPE500; Nom: POTEAU
Tekla Quantités - Poids: 0 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Hauteur: 500 mm; Largeur: 200 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Surface nette (m2) | Longueur (mm) | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
POTEAU | +8.046 | 15 | PT5 | 4 | 14.7 | 8230.7 | 8230.65 | 14.3543 | 0.0918782
POTEAU | +8.046 | 4 | PT4 | 1 | 14.7 | 8230.7 | 8230.65 | 14.3543 | 0.0918782
POTEAU | +8.440 | 3 | PT3 | 1 | 15.4 | 8625 | 8625 | 15.042 | 0.0963723
POTEAU | +8.046 | 5 | PT6 | 1 | 14.7 | 8230.7 | 8230.65 | 14.3543 | 0.0918782

# IfcColumn: IPE600 (2)
In: Undefined
Description: IPE600; Material: Undefined/S275-E28
Tekla Commun - Niveau bas: -0.185; Niveau haut: +8.540; Phase: 1; Classe: 2; Matériau: S275-E28; Profil: IPE600; Nom: POTEAU
Tekla Quantités - Poids: 0 kg; Volume: 0.1 m3; Surface supérieure totale: 0 m2; Surface nette: 18 m2; Hauteur: 600 mm; Largeur: 220 mm; Longueur: 8725 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - Length: 8725 mm; OuterSurfaceArea: 17.5809 m2; NetVolume: 0.131782 m3; NetWeight: 0 kg
Name | Repère de pièce = Reference | Repère d'assemblage
POTEAU | 14 | PT10
POTEAU | 26 | PT12

# IfcColumn: L100*10 (12)
In: Undefined
Description: L100*10; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L100*10; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 100 mm; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
ATTACHE | +7.104 | +7.225 | A23 | 120 | 0.0468 | 0.000228
ATTACHE | +7.090 | +7.220 | A22 | 130 | 0.0507 | 0.000247
2 x ATTACHE | +8.390 | +8.520 | A22 | 130 | 0.0507 | 0.000247
2 x ATTACHE | +5.030 | +5.160 | A22 | 130 | 0.0507 | 0.000247
2 x ATTACHE | +7.203 | +7.483 | A10 | 280 | 0.1092 | 0.000532
3 x ATTACHE | +7.970 | +8.210 | A11 | 240 | 0.0936 | 0.000456
ATTACHE | +7.343 | +7.523 | A9 | 180 | 0.0702 | 0.000342

# IfcColumn: L200*100*10 (2)
In: Undefined
Description: L200*100*10; Material: Undefined/S235-E24
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L200*100*10; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Largeur: 100 mm
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | Hauteur (mm) | Longueur (mm) = Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
ATTACHE | +8.450 | +8.550 | A52 | 150 | 100 | 0.0587 | 0.00024
ATTACHE | +7.143 | +7.224 | A51 | 200 | 80 | 0.04696 | 0.000232

# IfcColumn: L40*4 (3)
In: Undefined
Description: L40*4; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +7.100; Niveau haut: +7.220; Repère de pièce: A14; Repère d'assemblage: A14; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L40*4; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 40 mm; Largeur: 40 mm; Longueur: 120 mm
BaseQuantities - Length: 120 mm; OuterSurfaceArea: 0.0186 m2; NetVolume: 0.00003648 m3; NetWeight: 0 kg
Pset_ColumnCommon - LoadBearing: yes; Reference: A14

# IfcColumn: L60*6 (2)
In: Undefined
Description: L60*6; Material: Undefined/S235-E24
Tekla Commun - Niveau bas: +8.480; Niveau haut: +8.660; Repère de pièce: A45; Repère d'assemblage: A45; Finition: GALVA; Phase: 3; Classe: 2; Matériau: S235-E24; Profil: L60*6; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 60 mm; Largeur: 60 mm; Longueur: 180 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: A45
BaseQuantities - Length: 180 mm; OuterSurfaceArea: 0.04194 m2; NetVolume: 0.00012312 m3; NetWeight: 0 kg

# IfcColumn: L70*7 (3)
In: Undefined
Description: L70*7; Material: Undefined/S235-E24
Tekla Commun - Repère de pièce: A30; Repère d'assemblage: A30; Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L70*7; Nom: ATTACHE
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 70 mm; Largeur: 70 mm; Longueur: 100 mm
Pset_ColumnCommon - LoadBearing: yes; Reference: A30
BaseQuantities - Length: 100 mm; OuterSurfaceArea: 0.0272 m2; NetVolume: 0.0000931 m3; NetWeight: 0 kg
Name | Niveau bas | Niveau haut
ATTACHE | +7.100 | +7.200
ATTACHE | +2.760 | +2.860
ATTACHE | +4.450 | +4.550

# IfcColumn: L80*8 (3)
In: Undefined
Description: L80*8; Material: Undefined/S235-E24
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0 m2; Hauteur: 80 mm; Largeur: 80 mm
Tekla Commun - Phase: 1; Classe: 2; Matériau: S235-E24; Profil: L80*8; Nom: ATTACHE
Pset_ColumnCommon - LoadBearing: yes
BaseQuantities - NetWeight: 0 kg
Name | Longueur (mm) = Length (mm) | Niveau bas | Niveau haut | Repère de pièce = Repère d'assemblage = Reference | OuterSurfaceArea (m2) | NetVolume (m3)
2 x ATTACHE | 100 | +8.110 | +8.210 | A18 | 0.0311 | 0.0001216
ATTACHE | 120 | +3.255 | +3.375 | A8 | 0.03732 | 0.00014592

# IfcColumn: PL10*60 (40)
In: Undefined
Description: PL10*60; Material: Undefined/S235-E24
Tekla Quantités - Poids: 0 kg; Volume: 0 m3; Surface supérieure totale: 0 m2; Surface nette: 0.1 m2; Hauteur: 60 mm; Largeur: 10 mm
Tekla Commun - Matériau: S235-E24; Profil: PL10*60; Nom: MONTANT
BaseQuantities - NetWeight: 0 kg
Pset_ColumnCommon - LoadBearing: yes
Name | Longueur (mm) | Niveau bas | Niveau haut | Repère de pièce = Reference | Repère d'assemblage | Phase | Classe | Length (mm) | OuterSurfaceArea (m2) | NetVolume (m3)
MONTANT | 967.6 | +8.120 | +9.088 | 519(?) | GC0(?) | 3 | 4 | 967.6 | 0.133929 | 0.00056856 | Tekla Commun - Finition: GALVA
MONTANT | 967.6 | +8.710 | +9.678 | 0(?) | 0(?) | 3 | 4 | 967.6 | 0.133929 | 0.00056856 | Tekla Commun - Finition: GALVA
MONTANT | 967.6 | +8.710 | +9.678 | 519(?) | GC0(?) | 3 | 4 | 967.6 | 0.133929 | 0.00056856 | Tekla Commun - Finition: GALVA
2 x MONTANT | 967.6 | +8.710 | +9.678 | 518 | GC12 | 3 | 4 | 967.6 | 0.133929 | 0.00056856 | Tekla Commun - Finition: GALVA
2 x MONTANT | 967.6 | +8.120 | +9.088 | 519 | GC12 | 3 | 4 | 967.6 | 0.133929 | 0.00056856 | Tekla Commun - Finition: GALVA
MONTANT | 860.1 | +7.602 | +8.462 | 517 | GC12 | 3 | 4 | 860.124 | 0.117945 | 0.000499055 | Tekla Commun - Finition: GALVA
MONTANT | 937.6 | +8.920 | +9.858 | 509 | GC3 | 3 | 4 | 937.6 | 0.129729 | 0.00055056 | Tekla Commun - Finition: GALVA
MONTANT | 937.6 | +8.920 | +9.858 | 509 | GC2 | 3 | 4 | 937.6 | 0.129729 | 0.00055056 | Tekla Commun - Finition: GALVA
12 x MONTANT | 857.6 | +8.250 | +9.108 | 281 | MC3 | 1 | 5 | 857.6 | 0.118529 | 0.00050256
2 x MONTANT | 547.6 | +8.560 | +9.108 | 280 | MC2 | 1 | 5 | 547.6 | 0.0751289 | 0.00031656
12 x MONTANT | 857.6 | +8.250 | +9.108 | 281 | MC1 | 1 | 5 | 857.6 | 0.118529 | 0.00050256
